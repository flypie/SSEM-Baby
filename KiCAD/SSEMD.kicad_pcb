# Repository flypie/SSEM-Baby (continued)

## KiCad design KiCAD/SSEMD.kicad_pcb (continued)

Schematic: KVPSU1.sch, STABILISED KV PSU type 1 Position 4.9

Parts:
C-KVPSU1-1, C-KVPSU1-2: 1.5uf 3kV; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-KVPSU1-3, C-KVPSU1-4, C-KVPSU1-7, C-KVPSU1-8: 0.5; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-KVPSU1-5, C-KVPSU1-6, C-KVPSU1-9: 0.5uf 3kv; C_Disc_D7.5mm_W5.0mm_P5.00mm
F-KVPSU1-1, F-KVPSU1-2: 4A; Fuse_Littelfuse_395Series
J-KVPSU1-1: L; TerminalBlock_MetzConnect_360271_1x01_Horizontal_ScrewM3.0_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
J-KVPSU1-2: N; TerminalBlock_MetzConnect_360271_1x01_Horizontal_ScrewM3.0_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
J-KVPSU1-3: E; 242431
J-KVPSU1-4, J-KVPSU1-6: +4V L; TerminalBlock_MetzConnect_360271_1x01_Horizontal_ScrewM3.0_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
J-KVPSU1-5, J-KVPSU1-7: +4V N; TerminalBlock_MetzConnect_360271_1x01_Horizontal_ScrewM3.0_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
J-KVPSU1-8: JA77847; PinHeader_1x08_P2.54mm_Vertical
J-KVPSU1-9: 0V; TerminalBlock_MetzConnect_360271_1x01_Horizontal_ScrewM3.0_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
J-KVPSU1-10: S.EHT -KV; TerminalBlock_MetzConnect_360271_1x01_Horizontal_ScrewM3.0_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
L-KVPSU1-1: 100h 20 mA; PinHeader_1x02_P2.54mm_Vertical
M-KVPSU1-1: Voltmeter_DC; PinHeader_1x02_P2.54mm_Vertical
R-KVPSU1-1, R-KVPSU1-6, R-KVPSU1-9, R-KVPSU1-17: 2R 3W; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-KVPSU1-2: 0R8 4W; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-KVPSU1-3, R-KVPSU1-4: 470K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-KVPSU1-5: 1.5K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-KVPSU1-7, R-KVPSU1-16, R-KVPSU1-19, R-KVPSU1-21: 15k 3W; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-KVPSU1-8, R-KVPSU1-10: 22K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-KVPSU1-11, R-KVPSU1-12: 470; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-KVPSU1-13, R-KVPSU1-14: 470k; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-KVPSU1-15: 47k 2W; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-KVPSU1-18: 360k; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-KVPSU1-20: 4.5m; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R-KVPSU1-22: 4.7k; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
RV-KVPSU1-1: 500K WW; Potentiometer_Piher_PT-10-V05_Vertical
SW-KVPSU1-2: SW_SPST; PinHeader_1x04_P2.54mm_Vertical
TR-KVPSU1-1: VARIAC; PinHeader_1x10_P2.54mm_Vertical
TR-KVPSU1-2: Transformer_1P_1S; PinHeader_1x04_P2.54mm_Vertical
TR-KVPSU1-3: Transformer_1P_4S; PinHeader_1x10_P2.54mm_Vertical
U-KVPSU1-1: VU111; Valve_B4+1
U-KVPSU1-3: CV71; PinHeader_1x02_P2.54mm_Vertical
V-KVPSU1-1, V-KVPSU1-2: VR91; Valve_9Loctal
V-KVPSU1-3: CV73; Valve_9Loctal

Connections:
/KVPSU1/6.3V-L: J-KVPSU1-8.7, V-KVPSU1-1.1 (H), V-KVPSU1-2.1 (H), V-KVPSU1-3.5 (F1)
/KVPSU1/6.3V-N: J-KVPSU1-8.8, V-KVPSU1-1.9 (H), V-KVPSU1-2.9 (H), V-KVPSU1-3.4 (F1)
/KVPSU1/200*: R-KVPSU1-4.2, R-KVPSU1-19.1, R-KVPSU1-21.2, U-KVPSU1-3.1, V-KVPSU1-3.6 (K,BP)
/KVPSU1/+200: C-KVPSU1-5.1, C-KVPSU1-6.1, R-KVPSU1-11.1, R-KVPSU1-12.1
/KVPSU1/+300: J-KVPSU1-8.1, R-KVPSU1-5.1, R-KVPSU1-7.1, R-KVPSU1-8.1, R-KVPSU1-15.1, R-KVPSU1-16.1
/KVPSU1/GND: C-KVPSU1-3.1, C-KVPSU1-5.2, C-KVPSU1-6.2, C-KVPSU1-7.1, C-KVPSU1-8.1, J-KVPSU1-3.1, J-KVPSU1-8.5, J-KVPSU1-8.6, J-KVPSU1-9.1, M-KVPSU1-1.2 (+), R-KVPSU1-18.1, R-KVPSU1-21.1, V-KVPSU1-1.4 (G3), V-KVPSU1-1.6 (K), V-KVPSU1-2.4 (G3), V-KVPSU1-2.6 (K)
unnamed: C-KVPSU1-1.1, C-KVPSU1-2.1, R-KVPSU1-3.1, TR-KVPSU1-2.4 (SB), V-KVPSU1-3.8 (A)
unnamed: C-KVPSU1-1.2, L-KVPSU1-1.1, U-KVPSU1-1.5 (A)
unnamed: C-KVPSU1-2.2, C-KVPSU1-9.1, L-KVPSU1-1.2, M-KVPSU1-1.1 (-), R-KVPSU1-18.2, R-KVPSU1-20.2, R-KVPSU1-22.2
unnamed: C-KVPSU1-3.2, R-KVPSU1-7.2, V-KVPSU1-2.2 (G2)
unnamed: C-KVPSU1-4.1, R-KVPSU1-6.2, R-KVPSU1-8.2, V-KVPSU1-2.3 (A)
unnamed: C-KVPSU1-4.2, R-KVPSU1-10.1
unnamed: C-KVPSU1-7.2, R-KVPSU1-16.2, V-KVPSU1-1.2 (G2)
unnamed: C-KVPSU1-8.2, C-KVPSU1-9.2, R-KVPSU1-17.2, RV-KVPSU1-1.2
unnamed: F-KVPSU1-1.1, SW-KVPSU1-2.1 (A), TR-KVPSU1-3.1 (AA)
unnamed: F-KVPSU1-1.2, J-KVPSU1-1.1
unnamed: F-KVPSU1-2.1, TR-KVPSU1-1.1
unnamed: F-KVPSU1-2.2, SW-KVPSU1-2.2 (B)
unnamed: J-KVPSU1-2.1, TR-KVPSU1-1.2, TR-KVPSU1-2.2 (AB), TR-KVPSU1-3.2 (AB)
unnamed: J-KVPSU1-4.1, TR-KVPSU1-3.7 (SC)
unnamed: J-KVPSU1-5.1, TR-KVPSU1-3.8 (SD)
unnamed: J-KVPSU1-6.1, TR-KVPSU1-3.9 (SC)
unnamed: J-KVPSU1-7.1, TR-KVPSU1-3.10 (SD)
unnamed: J-KVPSU1-8.2, R-KVPSU1-11.2
unnamed: J-KVPSU1-8.4, R-KVPSU1-12.2
unnamed: J-KVPSU1-10.1, R-KVPSU1-22.1
unnamed: R-KVPSU1-1.1, TR-KVPSU1-3.4 (SB)
unnamed: R-KVPSU1-1.2, U-KVPSU1-1.3 (F)
unnamed: R-KVPSU1-2.1, TR-KVPSU1-3.5 (SC)
unnamed: R-KVPSU1-3.2, R-KVPSU1-4.1, U-KVPSU1-3.2
unnamed: R-KVPSU1-5.2, V-KVPSU1-3.7 (G2)
unnamed: R-KVPSU1-6.1, V-KVPSU1-3.2 (G1)
unnamed: R-KVPSU1-9.1, V-KVPSU1-2.7 (G1)
unnamed: R-KVPSU1-9.2, R-KVPSU1-10.2, R-KVPSU1-13.2, R-KVPSU1-14.1
unnamed: R-KVPSU1-13.1, R-KVPSU1-15.2, V-KVPSU1-1.3 (A)
unnamed: R-KVPSU1-17.1, V-KVPSU1-1.7 (G1)
unnamed: R-KVPSU1-19.2, RV-KVPSU1-1.3
unnamed: R-KVPSU1-20.1, RV-KVPSU1-1.1
unnamed: TR-KVPSU1-1.3, TR-KVPSU1-2.1 (AA)
unnamed: TR-KVPSU1-2.3 (SA), TR-KVPSU1-3.3 (SA), U-KVPSU1-1.4 (F)

Notes on the sheet:
4v 3A for CV73
6.3v 2A
4.1v 1A
NOTE. Two supplies are needed - one for the storage tubes, the other for the monitor tube. Two diferent units are shown on photo AAR10, with differeing meter arrangements. The above circuit may be adapted for the two different uses. The regulator valve must have enough, but not excessive, voltage a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
Aux Supply
Variac
2KV

Schematic: KVPSU2.sch, STABILISED KV PSU type 2 (For Monitor CRT) Position 4.8

Parts:
C-KVPSU2-1: 1.5uf 3kV; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-KVPSU2-2, C-KVPSU2-3: 4.5uf 1.5kV; C_Disc_D7.5mm_W5.0mm_P5.00mm
F-KVPSU2-1, F-KVPSU2-2: 4A; Fuse_Littelfuse_395Series
J-KVPSU2-1: L; 242431
J-KVPSU2-2: N; 242431
J-KVPSU2-3: E; 242431
J-KVPSU2-4: +4V L; 242431
J-KVPSU2-5: 0V; 242431
J-KVPSU2-6: M.EHT; 242431
J-KVPSU2-7: +4V N; 242431
L-KVPSU2-1: 100h 20 mA; PinHeader_1x02_P2.54mm_Vertical
MES-KVPSU2-1: 2.5 KV; PinHeader_1x02_P2.54mm_Vertical
R-KVPSU2-1: 2R 3W; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-KVPSU2-2: 700K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-KVPSU2-3: 800K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-KVPSU2-4: .7k; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
SW-KVPSU2-2: EHT switch; PinHeader_1x04_P2.54mm_Vertical
TR-KVPSU2-1: VARIAC; PinHeader_1x10_P2.54mm_Vertical
TR-KVPSU2-2: Transformer_1P_1S; PinHeader_1x04_P2.54mm_Vertical
TR-KVPSU2-3: Transformer_1P_4S; PinHeader_1x10_P2.54mm_Vertical
V-KVPSU2-1: VU111; Valve_B4+1
V-KVPSU2-4: CV71; PinHeader_1x02_P2.54mm_Vertical

Connections:
/KVPSU2/GND: C-KVPSU2-1.1, C-KVPSU2-3.1, J-KVPSU2-3.1, J-KVPSU2-5.1, MES-KVPSU2-1.2 (+), R-KVPSU2-2.1, TR-KVPSU2-2.4 (SB)
unnamed: C-KVPSU2-1.2, L-KVPSU2-1.1, V-KVPSU2-1.5 (A)
unnamed: C-KVPSU2-2.1, C-KVPSU2-3.2, R-KVPSU2-2.2, R-KVPSU2-3.1
unnamed: C-KVPSU2-2.2, L-KVPSU2-1.2, MES-KVPSU2-1.1 (-), R-KVPSU2-3.2, R-KVPSU2-4.2
unnamed: F-KVPSU2-1.1, SW-KVPSU2-2.1 (A), TR-KVPSU2-3.1 (AA)
unnamed: F-KVPSU2-1.2, J-KVPSU2-1.1
unnamed: F-KVPSU2-2.1, TR-KVPSU2-1.1, V-KVPSU2-4.2
unnamed: F-KVPSU2-2.2, SW-KVPSU2-2.2 (B)
unnamed: J-KVPSU2-2.1, R-KVPSU2-1.2, TR-KVPSU2-1.2, TR-KVPSU2-2.2 (AB), TR-KVPSU2-3.2 (AB)
unnamed: J-KVPSU2-4.1, TR-KVPSU2-3.9 (SC)
unnamed: J-KVPSU2-6.1, R-KVPSU2-4.1
unnamed: J-KVPSU2-7.1, TR-KVPSU2-3.10 (SD)
unnamed: R-KVPSU2-1.1, V-KVPSU2-4.1
unnamed: TR-KVPSU2-1.3, TR-KVPSU2-2.1 (AA)
unnamed: TR-KVPSU2-2.3 (SA), TR-KVPSU2-3.3 (SA), V-KVPSU2-1.4 (F)
unnamed: TR-KVPSU2-3.4 (SB), V-KVPSU2-1.3 (F)

Notes on the sheet:
1.1v 1A
6.2v 2A
4.1v 1A
Aux Supply
2KV
Variac
6.3v 3A

Schematic: L-STAT.sch, L-STAT& YSHIFT Positions 3.5,3.6,37,3.8,3.9

Parts:
C-L-STAT-1: 47p; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-L-STAT-2, C-L-STAT-3, C-L-STAT-4, C-L-STAT-6: 100pF; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-L-STAT-5, C-L-STAT-9, C-L-STAT-10: 0.1; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-L-STAT-7: 47pF; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-L-STAT-8: 2^(n-1)*0.01; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-L-STAT-11, C-L-STAT-13, C-L-STAT-14, C-L-STAT-15: 0.5; C_Disc_D7.5mm_W5.0mm_P5.00mm
D-L-STAT-5, D-L-STAT-6, D-L-STAT-7, D-L-STAT-8, D-L-STAT-9: EA50; Valve_B3G
J-L-STAT-1: Cn-1; 242431
J-L-STAT-2: Cl-N; 242431
J-L-STAT-3: P.n; 242431
J-L-STAT-4, J-L-STAT-5: HA; 242431
J-L-STAT-6: Cn; 242431
J-L-STAT-7: HS; 242431
J-L-STAT-17: HIGH Voltage.; TE_MATE-N-LOK_1-770970-x_2x04_P4.14mm_Horizontal
R-L-STAT-1, R-L-STAT-2: 47K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-L-STAT-3, R-L-STAT-9, R-L-STAT-10, R-L-STAT-15, R-L-STAT-19, R-L-STAT-22, R-L-STAT-23, R-L-STAT-29: 330K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-L-STAT-4: 560K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-L-STAT-5, R-L-STAT-17: 10K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-L-STAT-6, R-L-STAT-7, R-L-STAT-14, R-L-STAT-16: 47K 1W; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-L-STAT-8, R-L-STAT-12, R-L-STAT-13, R-L-STAT-20: 390K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-L-STAT-11, R-L-STAT-21: 19K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-L-STAT-18: 180K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-L-STAT-24: 1M; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-L-STAT-25: 11K 2W; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-L-STAT-26, R-L-STAT-28: 15K 2W; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-L-STAT-27: 33K 2W; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-L-STAT-30, R-L-STAT-33: 100K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-L-STAT-31: 470; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-L-STAT-32: 9K 6W; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-L-STAT-34: 270K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-L-STAT-35: R; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
RV-L-STAT-36: R'; 3362H1103LF
V-L-STAT-1, V-L-STAT-2: 6SN7GT; Valve_Octal
V-L-STAT-3, V-L-STAT-4, V-L-STAT-5, V-L-STAT-6, V-L-STAT-7, V-L-STAT-8, V-L-STAT-9: VR91; Valve_9Loctal

Connections:
/L-STAT/+50V: C-L-STAT-15.1, J-L-STAT-17.6
/L-STAT/+200V: C-L-STAT-13.1, J-L-STAT-17.3, R-L-STAT-11.2, R-L-STAT-21.2, V-L-STAT-2.2 (A2)
/L-STAT/+300V: C-L-STAT-11.1, J-L-STAT-17.4, R-L-STAT-1.2, R-L-STAT-7.2, R-L-STAT-14.2, R-L-STAT-26.2, R-L-STAT-27.2, R-L-STAT-28.2, V-L-STAT-2.5 (A1), V-L-STAT-9.2 (G2), V-L-STAT-9.3 (A), V-L-STAT-9.4 (G3)
/L-STAT/-150V: C-L-STAT-14.2, J-L-STAT-17.5, R-L-STAT-3.1, R-L-STAT-4.1, R-L-STAT-9.1, R-L-STAT-10.1, R-L-STAT-15.1, R-L-STAT-19.1, R-L-STAT-25.1, R-L-STAT-32.1, R-L-STAT-34.1, RV-L-STAT-36.2
/L-STAT/GND: C-L-STAT-5.2, C-L-STAT-9.2, C-L-STAT-10.2, C-L-STAT-11.2, C-L-STAT-13.2, C-L-STAT-14.1, C-L-STAT-15.2, D-L-STAT-7.2 (K), J-L-STAT-17.8, R-L-STAT-2.1, R-L-STAT-18.1, R-L-STAT-24.1, V-L-STAT-1.3 (K2), V-L-STAT-1.6 (K1), V-L-STAT-2.3 (K2), V-L-STAT-3.6 (K), V-L-STAT-4.6 (K), V-L-STAT-5.6 (K), V-L-STAT-6.6 (K)
/L-STAT/Heater-6.3V: D-L-STAT-5.1 (H), D-L-STAT-6.1 (H), D-L-STAT-7.1 (H), D-L-STAT-8.1 (H), J-L-STAT-17.2, V-L-STAT-1.8 (H), V-L-STAT-2.8 (H), V-L-STAT-3.9 (H), V-L-STAT-4.9 (H), V-L-STAT-5.9 (H), V-L-STAT-6.9 (H), V-L-STAT-7.9 (H), V-L-STAT-8.9 (H)
/L-STAT/Heater-GND: D-L-STAT-5.3 (H), D-L-STAT-6.3 (H), D-L-STAT-7.3 (H), D-L-STAT-8.3 (H), J-L-STAT-17.1, V-L-STAT-1.7 (H), V-L-STAT-2.7 (H), V-L-STAT-3.1 (H), V-L-STAT-4.1 (H), V-L-STAT-5.1 (H), V-L-STAT-6.1 (H), V-L-STAT-7.1 (H), V-L-STAT-8.1 (H)
unnamed: C-L-STAT-1.1, R-L-STAT-2.2, R-L-STAT-3.2, V-L-STAT-2.1 (G2)
unnamed: C-L-STAT-1.2, J-L-STAT-1.1
unnamed: C-L-STAT-2.1, R-L-STAT-8.2, R-L-STAT-10.2, R-L-STAT-16.2, R-L-STAT-23.1
unnamed: C-L-STAT-2.2, R-L-STAT-7.1, R-L-STAT-8.1, V-L-STAT-6.3 (A)
unnamed: C-L-STAT-3.1, D-L-STAT-7.4 (A), R-L-STAT-6.2, R-L-STAT-9.2, R-L-STAT-12.2
unnamed: C-L-STAT-3.2, R-L-STAT-12.1, R-L-STAT-14.1, V-L-STAT-5.3 (A)
unnamed: C-L-STAT-4.1, R-L-STAT-13.2, R-L-STAT-19.2, V-L-STAT-1.4 (G1)
unnamed: C-L-STAT-4.2, R-L-STAT-11.1, R-L-STAT-13.1, V-L-STAT-1.2 (A2)
unnamed: C-L-STAT-5.1, V-L-STAT-5.2 (G2), V-L-STAT-6.2 (G2)
unnamed: C-L-STAT-6.1, R-L-STAT-15.2, R-L-STAT-20.2, V-L-STAT-1.1 (G2)
unnamed: C-L-STAT-6.2, C-L-STAT-8.1, R-L-STAT-20.1, R-L-STAT-21.1, V-L-STAT-1.5 (A1)
unnamed: C-L-STAT-7.1, R-L-STAT-17.2, R-L-STAT-18.2
unnamed: C-L-STAT-7.2, J-L-STAT-4.1, J-L-STAT-5.1, R-L-STAT-22.1
unnamed: C-L-STAT-8.2, R-L-STAT-24.2, V-L-STAT-2.4 (G1)
unnamed: C-L-STAT-9.1, R-L-STAT-26.1, V-L-STAT-4.2 (G2)
unnamed: C-L-STAT-10.1, R-L-STAT-28.1, V-L-STAT-3.2 (G2)
unnamed: D-L-STAT-5.2 (K), D-L-STAT-6.2 (K), R-L-STAT-35.2
unnamed: D-L-STAT-6.4 (A), R-L-STAT-33.1, R-L-STAT-34.2
unnamed: D-L-STAT-8.2 (K), D-L-STAT-9.2 (K), R-L-STAT-4.2, R-L-STAT-5.1
unnamed: D-L-STAT-8.4 (A), J-L-STAT-2.1, R-L-STAT-1.1
unnamed: D-L-STAT-9.4 (A), J-L-STAT-3.1
unnamed: J-L-STAT-6.1, R-L-STAT-25.2, R-L-STAT-30.1, V-L-STAT-2.6 (K1)
unnamed: J-L-STAT-7.1, R-L-STAT-29.1
unnamed: R-L-STAT-5.2, V-L-STAT-6.7 (G1)
unnamed: R-L-STAT-6.1, V-L-STAT-6.4 (G3)
unnamed: R-L-STAT-16.1, V-L-STAT-5.4 (G3)
unnamed: R-L-STAT-17.1, V-L-STAT-5.7 (G1)
unnamed: R-L-STAT-22.2, V-L-STAT-4.4 (G3)
unnamed: R-L-STAT-23.2, V-L-STAT-4.7 (G1)
unnamed: R-L-STAT-27.1, R-L-STAT-31.2, V-L-STAT-3.3 (A), V-L-STAT-4.3 (A)
unnamed: R-L-STAT-29.2, V-L-STAT-3.4 (G3)
unnamed: R-L-STAT-30.2, V-L-STAT-3.7 (G1)
unnamed: R-L-STAT-31.1, V-L-STAT-9.7 (G1)
unnamed: R-L-STAT-32.2, R-L-STAT-33.2, V-L-STAT-9.6 (K)
unnamed: R-L-STAT-35.1, RV-L-STAT-36.1

Notes on the sheet:
CO driven by Ha
To Dummy Store
n 1 2 3 4 5 6 R 1M2 560K+68K 300k 150k 75k 36k R’ (w/w) 100k 55k 25k 25k 10k 5k
This circuit is included on chassis 37,3.8 and 3.9 only.

Schematic: MONICCT.sch, Monitor CRT Position 4.4

Parts:
C-MONICCT-1: 0.5 4kV; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-MONICCT-2, C-MONICCT-3: 0.1; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-MONICCT-4, C-MONICCT-5: 0.1 350V; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-MONICCT-7: 0.25 4kv; C_Disc_D7.5mm_W5.0mm_P5.00mm
D-MONICCT-1: EA50; Valve_B3G
J-MONICCT-1: STOP.LAMP; 242431
J-MONICCT-2: Y2; 242431
J-MONICCT-3: A.Y1; 242431
J-MONICCT-4: A.X2; 242431
J-MONICCT-5: A.X1; 242431
J-MONICCT-6: +300; 242431
J-MONICCT-7: M.GRID; 242431
J-MONICCT-16: HIGH Voltage.; TE_MATE-N-LOK_1-770970-x_2x04_P4.14mm_Horizontal
R-MONICCT-1: 1980K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-MONICCT-2, R-MONICCT-3: 1K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-MONICCT-4: 470K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-MONICCT-5: 270K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-MONICCT-6: 2M2; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-MONICCT-7: 22K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-MONICCT-8: 2R 3W; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
RV-MONICCT-1: 500K; Potentiometer_Bourns_3339P_Vertical_HandSoldering
RV-MONICCT-2, RV-MONICCT-3: 100K; Potentiometer_Bourns_3339P_Vertical_HandSoldering
V-MONICCT-1: VCR97; B12D

Connections:
/MONICCT/GND: C-MONICCT-1.2, C-MONICCT-2.1, C-MONICCT-3.1, J-MONICCT-1.2 (Ext), J-MONICCT-6.2 (Ext), J-MONICCT-7.2 (Ext), J-MONICCT-16.8, R-MONICCT-1.2, RV-MONICCT-2.1
/MONICCT/Heater-6.3V: C-MONICCT-4.1, D-MONICCT-1.1 (J), J-MONICCT-16.2, R-MONICCT-2.1, V-MONICCT-1.3 (h)
/MONICCT/Heater-GND: D-MONICCT-1.3 (J), J-MONICCT-16.1, R-MONICCT-8.1
/MONICCT/M.EHT(800-1400V): C-MONICCT-4.2, C-MONICCT-5.2, D-MONICCT-1.2 (K), R-MONICCT-6.1, R-MONICCT-7.1
unnamed: C-MONICCT-1.1, R-MONICCT-4.1, V-MONICCT-1.6 (A2)
unnamed: C-MONICCT-2.2, RV-MONICCT-2.2, V-MONICCT-1.5 (A1), V-MONICCT-1.7 (CC), V-MONICCT-1.10 (A3)
unnamed: C-MONICCT-3.2, J-MONICCT-6.1 (In), RV-MONICCT-2.3
unnamed: C-MONICCT-5.1, R-MONICCT-3.1, R-MONICCT-8.2, V-MONICCT-1.4 (h)
unnamed: C-MONICCT-7.1, J-MONICCT-7.1 (In)
unnamed: C-MONICCT-7.2, D-MONICCT-1.4 (A), R-MONICCT-6.2, V-MONICCT-1.1 (G1)
unnamed: J-MONICCT-2.1, V-MONICCT-1.8 (y2)
unnamed: J-MONICCT-3.1, V-MONICCT-1.12 (y1)
unnamed: J-MONICCT-4.1, V-MONICCT-1.9 (x2)
unnamed: J-MONICCT-5.1, V-MONICCT-1.11 (x1)
unnamed: R-MONICCT-1.1, RV-MONICCT-1.1
unnamed: R-MONICCT-2.2, R-MONICCT-3.2, RV-MONICCT-3.2, V-MONICCT-1.2 (K)
unnamed: R-MONICCT-4.2, RV-MONICCT-1.2
unnamed: R-MONICCT-5.1, RV-MONICCT-3.1
unnamed: R-MONICCT-5.2, RV-MONICCT-1.3
unnamed: R-MONICCT-7.2, RV-MONICCT-3.3

Notes on the sheet:
ASTIG
FOCUS
BRILL
6.3V elevated to kV
Lamp mounted on the front of the unit. Position 4.45

Schematic: MONSW.sch, Monitor Switch Position 6.9

Parts:
C-MONSW-1, C-MONSW-3, C-MONSW-9: 1000; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-MONSW-2, C-MONSW-6, C-MONSW-10: 0.1; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-MONSW-4, C-MONSW-5, C-MONSW-7, C-MONSW-8, C-MONSW-11: 0.5; C_Disc_D7.5mm_W5.0mm_P5.00mm
D-MONSW-1, D-MONSW-2, D-MONSW-3: EA50; Valve_B3G
J-MONSW1: C.GRID; 242431
J-MONSW2: A.GRID; 242431
J-MONSW3: S.GRID; 242431
J-MONSW4: B; 242431
J-MONSW5, J-MONSW9: MON.S; 242431
J-MONSW6: M; 242431
J-MONSW7, J-MONSW8: KM.cmn; 242431
J-MONSW10, J-MONSW11: MON.A; 242431
J-MONSW12, J-MONSW13: MON.C; 242431
J-MONSW14, J-MONSW15: SUP.ACT.LN; 242431
J-MONSW-5: HIGH Voltage.; TE_MATE-N-LOK_1-770970-x_2x04_P4.14mm_Horizontal
R-MONSW-1, R-MONSW-5, R-MONSW-9: R 2W; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-MONSW-2, R-MONSW-6, R-MONSW-10: 33K 2W; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-MONSW-3, R-MONSW-7, R-MONSW-11: 1M; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-MONSW-4: 1K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-MONSW-8: 15K 3W; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-MONSW-12, R-MONSW-13: 10M; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-MONSW-14, R-MONSW-17: 4.7K 6W; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-MONSW-15: 330K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-MONSW-16, R-MONSW-20: R; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-MONSW-18, R-MONSW-19: 47K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
SW1, SW2, SW3, SW4, SW5: SW_Push; PinHeader_1x02_P2.54mm_Vertical
SW-MONSW-1: SW-MONSW-1; M2011SS1W03
V-MONSW-1, V-MONSW-3, V-MONSW-4, V-MONSW-5, V-MONSW-6, V-MONSW-7: VR91; Valve_9Loctal
V-MONSW-2, V-MONSW-8: CV173; Valve_9Loctal
V-MONSW-?=7: VR91; Valve_9Loctal

Connections:
/MONSW/+50V: C-MONSW-8.1, J-MONSW-5.6
/MONSW/+100V: C-MONSW-11.1, R-MONSW-3.2, R-MONSW-7.2, R-MONSW-11.2, R-MONSW-18.1, R-MONSW-19.2
/MONSW/+200V: C-MONSW-5.1, J-MONSW-5.3, R-MONSW-15.2, R-MONSW-18.2, V-MONSW-1.2 (G2), V-MONSW-1.3 (A), V-MONSW-1.4 (G3), V-MONSW-3.2 (G2), V-MONSW-3.3 (A), V-MONSW-3.4 (G3), V-MONSW-4.2 (G2), V-MONSW-4.3 (A), V-MONSW-4.4 (G3), V-MONSW-6.2 (G2), V-MONSW-6.3 (A), V-MONSW-6.4 (G3), V-MONSW-7.2 (G2), V-MONSW-7.3 (A), V-MONSW-7.4 (G3), V-MONSW-8.3 (A)
/MONSW/+300V: C-MONSW-4.1, J-MONSW-5.4
/MONSW/-150V: C-MONSW-7.2, J-MONSW-5.5, R-MONSW-4.1, R-MONSW-14.1, R-MONSW-17.1
/MONSW/GND: C-MONSW-1.2, C-MONSW-3.2, C-MONSW-4.2, C-MONSW-5.2, C-MONSW-7.1, C-MONSW-8.2, C-MONSW-9.2, C-MONSW-11.2, J-MONSW-5.8, R-MONSW-8.1, R-MONSW-19.1
/MONSW/Heater-6.3V: D-MONSW-1.1 (H), D-MONSW-2.1 (H), D-MONSW-3.1 (H), J-MONSW-5.2, V-MONSW-1.9 (H), V-MONSW-2.9 (H), V-MONSW-3.9 (H), V-MONSW-4.9 (H), V-MONSW-5.9 (H), V-MONSW-6.9 (H), V-MONSW-?=7.9 (H)
/MONSW/Heater-GND: D-MONSW-1.3 (H), D-MONSW-2.3 (H), D-MONSW-3.3 (H), J-MONSW-5.1, V-MONSW-1.1 (H), V-MONSW-2.1 (H), V-MONSW-3.1 (H), V-MONSW-4.1 (H), V-MONSW-5.1 (H)
/MONSW/M.GRID: R-MONSW-17.2, V-MONSW-6.6 (K), V-MONSW-7.6 (K)
unnamed: C-MONSW-1.1, J-MONSW5.1, R-MONSW-2.1
unnamed: C-MONSW-2.2, R-MONSW-2.2, R-MONSW-3.1, V-MONSW-1.6 (K)
unnamed: C-MONSW-3.1, J-MONSW11.1, R-MONSW-6.1
unnamed: C-MONSW-6.2, R-MONSW-6.2, R-MONSW-7.1, V-MONSW-3.6 (K)
unnamed: C-MONSW-9.1, J-MONSW13.1, R-MONSW-10.1
unnamed: C-MONSW-2.1, C-MONSW-6.1, C-MONSW-10.1, D-MONSW-1.2 (K), R-MONSW-12.2, R-MONSW-13.1
unnamed: C-MONSW-10.2, R-MONSW-10.2, R-MONSW-11.1, V-MONSW-4.6 (K)
unnamed: D-MONSW-1.4 (A), R-MONSW-12.1
unnamed: D-MONSW-2.2 (K), R-MONSW-14.2, V-MONSW-8.6 (K)
unnamed: D-MONSW-2.4 (A), D-MONSW-3.4 (A), R-MONSW-15.1, R-MONSW-16.1
unnamed: D-MONSW-3.2 (K), J-MONSW14.1, R-MONSW-8.2
unnamed: J-MONSW1.1, R-MONSW-9.2
unnamed: J-MONSW2.1, R-MONSW-5.2
unnamed: J-MONSW3.1, R-MONSW-1.2
unnamed: J-MONSW4.1, SW1.1
unnamed: J-MONSW6.1, SW2.1
unnamed: J-MONSW7.1, SW1.2, SW2.2, SW3.2, SW4.2, SW5.2
unnamed: J-MONSW8.1, R-MONSW-4.2
unnamed: J-MONSW9.1, SW3.1
unnamed: J-MONSW10.1, SW4.1
unnamed: J-MONSW12.1, SW5.1
unnamed: J-MONSW15.1, SW-MONSW-1.2 (B)
unnamed: R-MONSW-1.1, V-MONSW-1.7 (G1)
unnamed: R-MONSW-5.1, V-MONSW-3.7 (G1)
unnamed: R-MONSW-9.1, V-MONSW-4.7 (G1)
unnamed: R-MONSW-13.2, V-MONSW-8.7 (G1)
unnamed: R-MONSW-16.2, V-MONSW-6.7 (G1)
unnamed: V-MONSW-6.1 (H), V-MONSW-?=7.1 (H)
unnamed: V-MONSW-8.2 (G2), V-MONSW-8.4 (G3)

Notes on the sheet:
Monitor switches mounted on Control panel
To Monitor CRT grid
Suppress Action Line switch, mounted on the Control Panel.
Circuit around V6 &V7 is modern innovation. The intent is to remove the highlighting effect of instruction and data accesses by gating off the beam during the action beat. This maybe removed as it is definitely not authentic!

Schematic: POWRCTL6b.sch, Power Control System

Parts:
CB-POWRCTL6b-1: RS_63C_16; PinHeader_1x06_P2.54mm_Vertical
CR-POWRCTL6b-1, CR-POWRCTL6b-4: DILA-22; PinHeader_1x10_P2.54mm_Vertical
CR-POWRCTL6b-A2, CR-POWRCTL6b-A3: DILA-40; PinHeader_1x10_P2.54mm_Vertical
CR-POWRCTL6b-B2: DILA-XHI10; PinHeader_1x10_P2.54mm_Vertical
CR-POWRCTL6b-B3: DILA-XHI01; PinHeader_1x10_P2.54mm_Vertical
D-POWRCTL6b-1, D-POWRCTL6b-2, D-POWRCTL6b-3, D-POWRCTL6b-4, D-POWRCTL6b-5, D-POWRCTL6b-6, D-POWRCTL6b-7, D-POWRCTL6b-8, D-POWRCTL6b-9, D-POWRCTL6b-10, D-POWRCTL6b-11, D-POWRCTL6b-12, D-POWRCTL6b-13, D-POWRCTL6b-14, D-POWRCTL6b-15, D-POWRCTL6b-16, D-POWRCTL6b-17, D-POWRCTL6b-18: D_Schottky 10A 150V; TO-46-2
F-POWRCTL6b-1: 1A; PinHeader_1x02_P2.54mm_Vertical
F-POWRCTL6b-2: 4A; PinHeader_1x02_P2.54mm_Vertical
F-POWRCTL6b-3, F-POWRCTL6b-4, F-POWRCTL6b-5: Fuse; PinHeader_1x02_P2.54mm_Vertical
J-POWRCTL6b-1, J-POWRCTL6b-2, J-POWRCTL6b-3, J-POWRCTL6b-4, J-POWRCTL6b-5: L; TerminalBlock_MetzConnect_360271_1x01_Horizontal_ScrewM3.0_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
J-POWRCTL6b-6, J-POWRCTL6b-7: 1; TerminalBlock_MetzConnect_360271_1x01_Horizontal_ScrewM3.0_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
J-POWRCTL6b-8, J-POWRCTL6b-9, J-POWRCTL6b-36, J-POWRCTL6b-41: 2; TerminalBlock_MetzConnect_360271_1x01_Horizontal_ScrewM3.0_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
J-POWRCTL6b-10, J-POWRCTL6b-11, J-POWRCTL6b-35, J-POWRCTL6b-37, J-POWRCTL6b-40, J-POWRCTL6b-42: 3; TerminalBlock_MetzConnect_360271_1x01_Horizontal_ScrewM3.0_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
J-POWRCTL6b-12: Conn_WallSocket; PinHeader_1x02_P2.54mm_Vertical
J-POWRCTL6b-13, J-POWRCTL6b-18, J-POWRCTL6b-33, J-POWRCTL6b-38: 5; TerminalBlock_MetzConnect_360271_1x01_Horizontal_ScrewM3.0_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
J-POWRCTL6b-14, J-POWRCTL6b-34, J-POWRCTL6b-39: 4; TerminalBlock_MetzConnect_360271_1x01_Horizontal_ScrewM3.0_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
J-POWRCTL6b-15: 6; TerminalBlock_MetzConnect_360271_1x01_Horizontal_ScrewM3.0_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
J-POWRCTL6b-16, J-POWRCTL6b-19: 7; TerminalBlock_MetzConnect_360271_1x01_Horizontal_ScrewM3.0_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
J-POWRCTL6b-17, J-POWRCTL6b-22: 10; TerminalBlock_MetzConnect_360271_1x01_Horizontal_ScrewM3.0_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
J-POWRCTL6b-20, J-POWRCTL6b-21: 8; TerminalBlock_MetzConnect_360271_1x01_Horizontal_ScrewM3.0_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
J-POWRCTL6b-23, J-POWRCTL6b-24, J-POWRCTL6b-27, J-POWRCTL6b-28, J-POWRCTL6b-29, J-POWRCTL6b-30, J-POWRCTL6b-31, J-POWRCTL6b-32: TerminalBlock_MetzConnect_360271_1x01_Horizontal_ScrewM3.0_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
J-POWRCTL6b-25: 12; TerminalBlock_MetzConnect_360271_1x01_Horizontal_ScrewM3.0_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
J-POWRCTL6b-26: 11; TerminalBlock_MetzConnect_360271_1x01_Horizontal_ScrewM3.0_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
MES-POWRCTL6b-1, MES-POWRCTL6b-5, MES-POWRCTL6b-6, MES-POWRCTL6b-7: 7V; PinHeader_1x02_P2.54mm_Vertical
MES-POWRCTL6b-2: 10A; PinHeader_1x02_P2.54mm_Vertical
MES-POWRCTL6b-3, MES-POWRCTL6b-4: 5A; PinHeader_1x02_P2.54mm_Vertical
P-POWRCTL6b-1: Conn_WallPlug; PinHeader_1x02_P2.54mm_Vertical
PSU-POWRCTL6b-1, PSU-POWRCTL6b-2, PSU-POWRCTL6b-3, PSU-POWRCTL6b-4, PSU-POWRCTL6b-5, PSU-POWRCTL6b-6: PSU-SSEM; PinHeader_1x09_P2.54mm_Vertical
R-POWRCTL6b-1, R-POWRCTL6b-2, R-POWRCTL6b-3: 2R 3W; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
RV-POWRCTL6b-1, RV-POWRCTL6b-2, RV-POWRCTL6b-3: 17R; PinHeader_1x03_P2.54mm_Vertical
SW-POWRCTL6b-1: SW_SPST; PinHeader_1x04_P2.54mm_Vertical
SW-POWRCTL6b-2: SW_Push; PinHeader_1x02_P2.54mm_Vertical
SW-POWRCTL6b-3: SW_Push_Open; PinHeader_1x02_P2.54mm_Vertical
SW-POWRCTL6b-4, SW-POWRCTL6b-5, SW-POWRCTL6b-6: SW_SPDT; PinHeader_1x03_P2.54mm_Vertical
T-POWRCTL6b-1, T-POWRCTL6b-2: Transformer_1P_2S; PinHeader_1x06_P2.54mm_Vertical
TR-POWRCTL6b-1: VARIAC; PinHeader_1x03_P2.54mm_Vertical
V-POWRCTL6b-1, V-POWRCTL6b-2, V-POWRCTL6b-3, V-POWRCTL6b-4: CV71; PinHeader_1x02_P2.54mm_Vertical

Connections:
/POWRCTL6b/0V: J-POWRCTL6b-5.1, J-POWRCTL6b-6.1, J-POWRCTL6b-41.1, MES-POWRCTL6b-5.1, MES-POWRCTL6b-6.2, MES-POWRCTL6b-7.1, PSU-POWRCTL6b-1.7 (E), PSU-POWRCTL6b-2.7 (E), PSU-POWRCTL6b-3.7 (E), PSU-POWRCTL6b-4.7 (E), PSU-POWRCTL6b-5.7 (E), PSU-POWRCTL6b-6.7 (E)
/POWRCTL6b/+200: MES-POWRCTL6b-3.2, R-POWRCTL6b-2.2
/POWRCTL6b/+300: MES-POWRCTL6b-2.2, MES-POWRCTL6b-5.2, MES-POWRCTL6b-7.2, R-POWRCTL6b-1.2
/POWRCTL6b/-150: MES-POWRCTL6b-4.2, MES-POWRCTL6b-6.1, R-POWRCTL6b-3.2
/POWRCTL6b/N: CR-POWRCTL6b-A3.2 (A2), J-POWRCTL6b-4.1, J-POWRCTL6b-8.1, J-POWRCTL6b-12.2 (AC_N), PSU-POWRCTL6b-1.8 (N), PSU-POWRCTL6b-2.8 (N), PSU-POWRCTL6b-3.8 (N), PSU-POWRCTL6b-4.8 (N), PSU-POWRCTL6b-5.8 (N), PSU-POWRCTL6b-6.8 (N), V-POWRCTL6b-1.1
unnamed: CB-POWRCTL6b-1.1 (A1), J-POWRCTL6b-1.1
unnamed: CB-POWRCTL6b-1.2 (A2), J-POWRCTL6b-2.1
unnamed: CB-POWRCTL6b-1.3 (A3), J-POWRCTL6b-3.1
unnamed: CB-POWRCTL6b-1.4 (B1), CR-POWRCTL6b-A3.4 (NO14)
unnamed: CB-POWRCTL6b-1.5 (B2), CR-POWRCTL6b-A3.6 (NO24)
unnamed: CB-POWRCTL6b-1.6 (B3), CR-POWRCTL6b-A3.8 (NO34), J-POWRCTL6b-10.1, J-POWRCTL6b-12.1 (AC_P), V-POWRCTL6b-1.2
unnamed: CR-POWRCTL6b-1.1 (A1), SW-POWRCTL6b-1.2 (B), SW-POWRCTL6b-3.2 (B)
unnamed: CR-POWRCTL6b-1.2 (A2), CR-POWRCTL6b-4.1 (A1), CR-POWRCTL6b-A2.2 (A), J-POWRCTL6b-9.1, J-POWRCTL6b-26.1, P-POWRCTL6b-1.2 (AC_N), T-POWRCTL6b-1.2 (AB), T-POWRCTL6b-2.2 (AB), TR-POWRCTL6b-1.2
unnamed: CR-POWRCTL6b-1.3 (NO13), CR-POWRCTL6b-1.5 (NC21), F-POWRCTL6b-2.2
unnamed: CR-POWRCTL6b-1.6 (NC22), CR-POWRCTL6b-1.8 (NC32), J-POWRCTL6b-22.1
unnamed: CR-POWRCTL6b-1.7 (NC31), CR-POWRCTL6b-1.9 (NO43), T-POWRCTL6b-1.1 (AA), T-POWRCTL6b-2.1 (AA)
unnamed: CR-POWRCTL6b-1.4 (NO14), CR-POWRCTL6b-1.10 (NO44), F-POWRCTL6b-1.2, J-POWRCTL6b-11.1
unnamed: CR-POWRCTL6b-4.2 (A2), J-POWRCTL6b-17.1, TR-POWRCTL6b-1.3
unnamed: CR-POWRCTL6b-4.3 (NO13), F-POWRCTL6b-1.1
unnamed: CR-POWRCTL6b-4.4 (NO14), SW-POWRCTL6b-1.1 (A)
unnamed: CR-POWRCTL6b-A2.1 (A), CR-POWRCTL6b-A2.3 (NO13), J-POWRCTL6b-21.1
unnamed: CR-POWRCTL6b-A2.4 (NO14), J-POWRCTL6b-18.1
unnamed: CR-POWRCTL6b-A2.5 (NO23), J-POWRCTL6b-42.1
unnamed: CR-POWRCTL6b-A2.6 (NO24), MES-POWRCTL6b-4.1, R-POWRCTL6b-3.1
unnamed: CR-POWRCTL6b-A2.7 (NO33), J-POWRCTL6b-40.1
unnamed: CR-POWRCTL6b-A2.9 (NO43), J-POWRCTL6b-39.1
unnamed: CR-POWRCTL6b-A2.10 (NO44), MES-POWRCTL6b-3.1, R-POWRCTL6b-2.1
unnamed: CR-POWRCTL6b-A3.1 (A1), CR-POWRCTL6b-A3.9 (NO43), CR-POWRCTL6b-B3.1 (NC51), J-POWRCTL6b-14.1
unnamed: CR-POWRCTL6b-A3.3 (NO13), PSU-POWRCTL6b-1.9 (L), PSU-POWRCTL6b-3.9 (L)
unnamed: CR-POWRCTL6b-A3.5 (NO23), PSU-POWRCTL6b-2.9 (L), PSU-POWRCTL6b-4.9 (L)
unnamed: CR-POWRCTL6b-A3.7 (NO33), PSU-POWRCTL6b-5.9 (L), PSU-POWRCTL6b-6.9 (L)
unnamed: CR-POWRCTL6b-A3.10 (NO44), J-POWRCTL6b-13.1, J-POWRCTL6b-15.1
unnamed: CR-POWRCTL6b-B2.1 (NO53), J-POWRCTL6b-38.1
unnamed: CR-POWRCTL6b-B2.2 (NO54), MES-POWRCTL6b-2.1, R-POWRCTL6b-1.1
unnamed: CR-POWRCTL6b-B3.2 (NC52), J-POWRCTL6b-16.1
unnamed: D-POWRCTL6b-1.1 (K), PSU-POWRCTL6b-1.4 (+75V), RV-POWRCTL6b-1.3, SW-POWRCTL6b-4.2 (B)
unnamed: D-POWRCTL6b-1.2 (A), D-POWRCTL6b-13.1 (K), PSU-POWRCTL6b-1.3 (+62.5V)
unnamed: D-POWRCTL6b-2.2 (A), PSU-POWRCTL6b-1.1 (0V)
unnamed: D-POWRCTL6b-3.1 (K), PSU-POWRCTL6b-2.4 (+75V)
unnamed: D-POWRCTL6b-4.2 (A), PSU-POWRCTL6b-2.1 (0V)
unnamed: D-POWRCTL6b-5.1 (K), PSU-POWRCTL6b-3.4 (+75V)
unnamed: D-POWRCTL6b-6.2 (A), PSU-POWRCTL6b-3.1 (0V)
unnamed: D-POWRCTL6b-7.1 (K), PSU-POWRCTL6b-4.4 (+75V)
unnamed: D-POWRCTL6b-8.2 (A), J-POWRCTL6b-36.1, PSU-POWRCTL6b-4.1 (0V)
unnamed: D-POWRCTL6b-9.1 (K), PSU-POWRCTL6b-5.4 (+75V)
unnamed: D-POWRCTL6b-10.1 (K), D-POWRCTL6b-17.2 (A), PSU-POWRCTL6b-5.2 (+50v)
unnamed: D-POWRCTL6b-10.2 (A), PSU-POWRCTL6b-5.1 (0V)
unnamed: D-POWRCTL6b-11.1 (K), PSU-POWRCTL6b-6.4 (+75V)
unnamed: D-POWRCTL6b-11.2 (A), D-POWRCTL6b-18.1 (K), PSU-POWRCTL6b-6.3 (+62.5V)
unnamed: D-POWRCTL6b-12.1 (K), D-POWRCTL6b-18.2 (A), PSU-POWRCTL6b-6.2 (+50v)
unnamed: D-POWRCTL6b-12.2 (A), PSU-POWRCTL6b-6.1 (0V), RV-POWRCTL6b-3.3, SW-POWRCTL6b-6.2 (B)
unnamed: D-POWRCTL6b-2.1 (K), D-POWRCTL6b-13.2 (A), PSU-POWRCTL6b-1.2 (+50v)
unnamed: D-POWRCTL6b-3.2 (A), D-POWRCTL6b-14.1 (K), PSU-POWRCTL6b-2.3 (+62.5V)
unnamed: D-POWRCTL6b-4.1 (K), D-POWRCTL6b-14.2 (A), PSU-POWRCTL6b-2.2 (+50v), RV-POWRCTL6b-2.3, SW-POWRCTL6b-5.2 (B)
unnamed: D-POWRCTL6b-5.2 (A), D-POWRCTL6b-15.1 (K), PSU-POWRCTL6b-3.3 (+62.5V)
unnamed: D-POWRCTL6b-6.1 (K), D-POWRCTL6b-15.2 (A), PSU-POWRCTL6b-3.2 (+50v)
unnamed: D-POWRCTL6b-7.2 (A), D-POWRCTL6b-16.1 (K), PSU-POWRCTL6b-4.3 (+62.5V)
unnamed: D-POWRCTL6b-8.1 (K), D-POWRCTL6b-16.2 (A), J-POWRCTL6b-35.1, PSU-POWRCTL6b-4.2 (+50v)
unnamed: D-POWRCTL6b-9.2 (A), D-POWRCTL6b-17.1 (K), PSU-POWRCTL6b-5.3 (+62.5V)
unnamed: F-POWRCTL6b-2.1, J-POWRCTL6b-25.1
unnamed: F-POWRCTL6b-3.1, J-POWRCTL6b-33.1, V-POWRCTL6b-2.2
unnamed: F-POWRCTL6b-3.2, RV-POWRCTL6b-1.1, RV-POWRCTL6b-1.2, SW-POWRCTL6b-4.1 (A), V-POWRCTL6b-2.1
unnamed: F-POWRCTL6b-4.1, J-POWRCTL6b-34.1, V-POWRCTL6b-3.2
unnamed: F-POWRCTL6b-4.2, RV-POWRCTL6b-2.1, RV-POWRCTL6b-2.2, SW-POWRCTL6b-5.1 (A), V-POWRCTL6b-3.1
unnamed: F-POWRCTL6b-5.1, J-POWRCTL6b-37.1, V-POWRCTL6b-4.2
unnamed: F-POWRCTL6b-5.2, RV-POWRCTL6b-3.1, RV-POWRCTL6b-3.2, SW-POWRCTL6b-6.1 (A), V-POWRCTL6b-4.1
unnamed: J-POWRCTL6b-19.1, SW-POWRCTL6b-2.1
unnamed: J-POWRCTL6b-20.1, SW-POWRCTL6b-2.2, SW-POWRCTL6b-3.1 (A)
unnamed: J-POWRCTL6b-23.1, MES-POWRCTL6b-1.2
unnamed: J-POWRCTL6b-24.1, MES-POWRCTL6b-1.1
unnamed: J-POWRCTL6b-7.1, J-POWRCTL6b-27.1
unnamed: J-POWRCTL6b-28.1, T-POWRCTL6b-1.3 (SA)
unnamed: J-POWRCTL6b-29.1, T-POWRCTL6b-1.4 (SB)
unnamed: P-POWRCTL6b-1.1 (AC_P), TR-POWRCTL6b-1.1
unnamed: PSU-POWRCTL6b-1.6, PSU-POWRCTL6b-2.5
unnamed: PSU-POWRCTL6b-2.6, PSU-POWRCTL6b-3.5
unnamed: PSU-POWRCTL6b-3.6, PSU-POWRCTL6b-4.5
unnamed: PSU-POWRCTL6b-4.6, PSU-POWRCTL6b-5.5
unnamed: PSU-POWRCTL6b-5.6, PSU-POWRCTL6b-6.5

Notes on the sheet:
Brown
Black
Grey
+300 Margins
+200 Margins
Blue
Green/Yellow
6.5V 50A
-150 Margins
Heater Transformers Panel
NOTE: The heaters load on the two transformers should be reasonably well balanced: as between the halves of the windings because the centre tap is not able to carry more than about 20A, and between the two transformers so that on standby (heaters OFF), all heaters run at about half voltage.
Meters Panel
HT Rack
Power Inlet Panel
Supp. OK link originally connected between 5 & 6

Schematic: PREPULSE.sch, Instruction Gate & Y Shift Position 4.1

Parts:
C-PREPULSE-1: 220p; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-PREPULSE-2: 2800pf; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-PREPULSE-3, C-PREPULSE-5, C-PREPULSE-6: 0.5; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-PREPULSE-4: 100p; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-PREPULSE-7, C-PREPULSE-10: 0.1u; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-PREPULSE-8: 47p; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-PREPULSE-9: 0.1; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-PREPULSE-11, C-PREPULSE-12, C-PREPULSE-13, C-PREPULSE-14: 100pf; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-PREPULSE-15: 220pf; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-PREPULSE--A-1: 0.5; C_Disc_D7.5mm_W5.0mm_P5.00mm
D-PREPULSE-1, D-PREPULSE-2, D-PREPULSE-3, D-PREPULSE-4, D-PREPULSE-5, D-PREPULSE-6, D-PREPULSE-7, D-PREPULSE-8, D-PREPULSE-9, D-PREPULSE-10, D-PREPULSE-11, D-PREPULSE-12, D-PREPULSE-13, D-PREPULSE-14, D-PREPULSE-15, D-PREPULSE-16, D-PREPULSE-17, D-PREPULSE-18, D-PREPULSE-19, D-PREPULSE-20: EA50; Valve_B3G
J-PREPULSE-1, J-PREPULSE-9: C0; 242431
J-PREPULSE-3, J-PREPULSE-11: Completion Signal (Prepulse); 242431
J-PREPULSE-4: P0.CF; 242431
J-PREPULSE-5: P1.CF; 242431
J-PREPULSE-6: Plus1; 242431
J-PREPULSE-7: Plus2; 242431
J-PREPULSE-8: Plus1or2; 242431
J-PREPULSE-10: HA; 242431
J-SCFOLLWS-15: HIGH Voltage.; TE_MATE-N-LOK_1-770972-x_2x06_P4.14mm_Horizontal
R-PREPULSE-1, R-PREPULSE-9: 51K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-PREPULSE-2, R-PREPULSE-11, R-PREPULSE-16, R-PREPULSE-21, R-PREPULSE-24, R-PREPULSE-27, R-PREPULSE-33, R-PREPULSE-37: 470; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-PREPULSE-3, R-PREPULSE-20, R-PREPULSE-34: 1M; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-PREPULSE-4, R-PREPULSE-6: 100K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-PREPULSE-5: 68K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-PREPULSE-7: 39K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-PREPULSE-8, R-PREPULSE-15, R-PREPULSE-22: 47K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-PREPULSE-10: 220uf; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-PREPULSE-12, R-PREPULSE-26: 220K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-PREPULSE-13: 3K9 6W; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-PREPULSE-14: 10M; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-PREPULSE-17: 750; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-PREPULSE-18: 15K 2W; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-PREPULSE-19, R-PREPULSE-30: 10K 3W; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-PREPULSE-23, R-PREPULSE-29, R-PREPULSE-39: 470K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-PREPULSE-25: 39K 1W; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-PREPULSE-28: 330K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-PREPULSE-31: 47K 2W; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-PREPULSE-32: 68K 3W; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-PREPULSE-35: 12K 2W; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-PREPULSE-36: 820K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-PREPULSE-38: 3.3k6W; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-PREPULSE-40: 22K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
SW-PREPULSE-1: SW_SPDT; PinHeader_1x03_P2.54mm_Vertical
SW-PREPULSE-2: SW_SPST; PinHeader_1x02_P2.54mm_Vertical
V-PREPULSE-1, V-PREPULSE-2, V-PREPULSE-3, V-PREPULSE-4, V-PREPULSE-5, V-PREPULSE-6: VR91; Valve_9Loctal

Connections:
/PREPULSE/+50V: C-PREPULSE-6.1, J-SCFOLLWS-15.3
/PREPULSE/+200V: C-PREPULSE-3.1, J-SCFOLLWS-15.2, V-PREPULSE-4.2 (G2), V-PREPULSE-4.3 (A), V-PREPULSE-4.4 (G3), V-PREPULSE-5.2 (G2), V-PREPULSE-5.3 (A), V-PREPULSE-5.4 (G3), V-PREPULSE-6.2 (G2), V-PREPULSE-6.3 (A), V-PREPULSE-6.4 (G3)
/PREPULSE/+300V: C-PREPULSE--A-1.1, J-SCFOLLWS-15.1, R-PREPULSE-3.1, R-PREPULSE-15.1, R-PREPULSE-18.1, R-PREPULSE-20.1, R-PREPULSE-22.1, R-PREPULSE-28.1, R-PREPULSE-31.1, R-PREPULSE-34.1, R-PREPULSE-35.1, R-PREPULSE-39.1
/PREPULSE/-150V: C-PREPULSE-5.2, J-SCFOLLWS-15.4, R-PREPULSE-7.2, R-PREPULSE-12.2, R-PREPULSE-13.2, R-PREPULSE-19.2, R-PREPULSE-25.2, R-PREPULSE-26.2, R-PREPULSE-32.2, R-PREPULSE-36.2, R-PREPULSE-38.2
/PREPULSE/GND: C-PREPULSE-2.2, C-PREPULSE-3.2, C-PREPULSE-4.2, C-PREPULSE-5.1, C-PREPULSE-6.2, C-PREPULSE-9.1, C-PREPULSE-10.2, C-PREPULSE-14.1, C-PREPULSE--A-1.2, D-PREPULSE-5.2 (K), D-PREPULSE-6.2 (K), D-PREPULSE-9.2 (K), D-PREPULSE-20.2 (K), J-SCFOLLWS-15.5, J-SCFOLLWS-15.6, R-PREPULSE-4.2, R-PREPULSE-5.2, R-PREPULSE-8.2, R-PREPULSE-10.1, R-PREPULSE-14.2, R-PREPULSE-17.1, V-PREPULSE-1.6 (K), V-PREPULSE-2.6 (K), V-PREPULSE-3.6 (K)
/PREPULSE/Heater-6.3V: D-PREPULSE-1.1 (H), D-PREPULSE-2.1 (H), D-PREPULSE-3.1 (H), D-PREPULSE-4.1 (H), D-PREPULSE-5.1 (H), D-PREPULSE-6.1 (H), D-PREPULSE-7.1 (H), D-PREPULSE-8.1 (H), D-PREPULSE-9.1 (H), D-PREPULSE-10.1 (H), D-PREPULSE-11.1 (H), D-PREPULSE-12.1 (H), D-PREPULSE-13.1 (H), D-PREPULSE-14.1 (H), D-PREPULSE-15.1 (H), D-PREPULSE-16.1 (H), D-PREPULSE-17.1 (H), D-PREPULSE-18.1 (H), D-PREPULSE-19.1 (H), D-PREPULSE-20.1 (H), J-SCFOLLWS-15.10, J-SCFOLLWS-15.12, V-PREPULSE-1.9 (H), V-PREPULSE-2.9 (H), V-PREPULSE-3.9 (H), V-PREPULSE-4.9 (H), V-PREPULSE-5.9 (H), V-PREPULSE-6.9 (H)
/PREPULSE/Heater-GND: D-PREPULSE-1.3 (H), D-PREPULSE-2.3 (H), D-PREPULSE-3.3 (H), D-PREPULSE-4.3 (H), D-PREPULSE-5.3 (H), D-PREPULSE-6.3 (H), D-PREPULSE-7.3 (H), D-PREPULSE-8.3 (H), D-PREPULSE-9.3 (H), D-PREPULSE-10.3 (H), J-SCFOLLWS-15.9, J-SCFOLLWS-15.11, V-PREPULSE-1.1 (H), V-PREPULSE-2.1 (H), V-PREPULSE-3.1 (H), V-PREPULSE-4.1 (H), V-PREPULSE-5.1 (H), V-PREPULSE-6.1 (H)
unnamed: C-PREPULSE-1.1, R-PREPULSE-1.1, R-PREPULSE-2.1, R-PREPULSE-8.1
unnamed: C-PREPULSE-1.2, J-PREPULSE-1.1
unnamed: C-PREPULSE-2.1, D-PREPULSE-1.2 (K), R-PREPULSE-3.2, R-PREPULSE-4.1, SW-PREPULSE-1.2 (B)
unnamed: C-PREPULSE-4.1, D-PREPULSE-2.2 (K), D-PREPULSE-3.4 (A), R-PREPULSE-14.1, R-PREPULSE-16.1
unnamed: C-PREPULSE-7.1, C-PREPULSE-8.2, R-PREPULSE-15.2, V-PREPULSE-1.3 (A)
unnamed: C-PREPULSE-7.2, R-PREPULSE-10.2
unnamed: C-PREPULSE-8.1, R-PREPULSE-20.2, R-PREPULSE-21.2
unnamed: C-PREPULSE-9.2, R-PREPULSE-9.2, R-PREPULSE-13.1, R-PREPULSE-17.2
unnamed: C-PREPULSE-10.1, R-PREPULSE-18.2, V-PREPULSE-1.2 (G2)
unnamed: C-PREPULSE-11.1, D-PREPULSE-6.4 (A), R-PREPULSE-23.1, R-PREPULSE-26.1, R-PREPULSE-27.1
unnamed: C-PREPULSE-11.2, R-PREPULSE-22.2, R-PREPULSE-23.2, V-PREPULSE-2.3 (A)
unnamed: C-PREPULSE-12.1, D-PREPULSE-5.4 (A), D-PREPULSE-7.4 (A), R-PREPULSE-12.1, R-PREPULSE-24.1, R-PREPULSE-29.1
unnamed: C-PREPULSE-12.2, R-PREPULSE-29.2, R-PREPULSE-31.2, V-PREPULSE-3.3 (A)
unnamed: C-PREPULSE-13.1, R-PREPULSE-33.2, R-PREPULSE-34.2
unnamed: C-PREPULSE-13.2, J-PREPULSE-9.1
unnamed: C-PREPULSE-14.2, R-PREPULSE-35.2, V-PREPULSE-3.2 (G2)
unnamed: C-PREPULSE-15.1, J-PREPULSE-10.1
unnamed: C-PREPULSE-15.2, R-PREPULSE-39.2, R-PREPULSE-40.1
unnamed: D-PREPULSE-1.4 (A), D-PREPULSE-3.2 (K), J-PREPULSE-11.1, R-PREPULSE-38.1, V-PREPULSE-4.6 (K)
unnamed: D-PREPULSE-2.4 (A), J-PREPULSE-3.1, R-PREPULSE-5.1, R-PREPULSE-7.1
unnamed: D-PREPULSE-7.2 (K), D-PREPULSE-8.2 (K), D-PREPULSE-9.4 (A), R-PREPULSE-36.1, R-PREPULSE-37.2
unnamed: D-PREPULSE-8.4 (A), R-PREPULSE-40.2
unnamed: D-PREPULSE-11.3 (H), D-PREPULSE-12.3 (H), D-PREPULSE-13.3 (H), D-PREPULSE-14.3 (H), D-PREPULSE-15.3 (H), D-PREPULSE-16.3 (H), D-PREPULSE-17.3 (H), D-PREPULSE-18.3 (H), D-PREPULSE-19.3 (H), D-PREPULSE-20.3 (H)
unnamed: D-PREPULSE-12.2 (K), D-PREPULSE-13.2 (K), D-PREPULSE-14.2 (K), D-PREPULSE-18.2 (K)
unnamed: D-PREPULSE-12.4 (A), D-PREPULSE-15.4 (A), R-PREPULSE-19.1, V-PREPULSE-5.6 (K)
unnamed: D-PREPULSE-13.4 (A), J-PREPULSE-4.1
unnamed: D-PREPULSE-14.4 (A), J-PREPULSE-6.1
unnamed: D-PREPULSE-15.2 (K), D-PREPULSE-16.2 (K), D-PREPULSE-17.2 (K), D-PREPULSE-19.2 (K), R-PREPULSE-25.1
unnamed: D-PREPULSE-16.4 (A), J-PREPULSE-5.1
unnamed: D-PREPULSE-17.4 (A), J-PREPULSE-7.1
unnamed: D-PREPULSE-18.4 (A), D-PREPULSE-19.4 (A), D-PREPULSE-20.4 (A), R-PREPULSE-28.2, R-PREPULSE-30.2
unnamed: J-PREPULSE-8.1, R-PREPULSE-32.1, V-PREPULSE-6.6 (K)
unnamed: R-PREPULSE-2.2, V-PREPULSE-1.4 (G3)
unnamed: R-PREPULSE-6.2, SW-PREPULSE-2.1 (A)
unnamed: R-PREPULSE-6.1, R-PREPULSE-9.1, R-PREPULSE-11.1, SW-PREPULSE-1.3 (C)
unnamed: R-PREPULSE-11.2, V-PREPULSE-1.7 (G1)
unnamed: R-PREPULSE-16.2, V-PREPULSE-5.7 (G1)
unnamed: R-PREPULSE-21.1, V-PREPULSE-2.7 (G1)
unnamed: R-PREPULSE-24.2, V-PREPULSE-2.4 (G3)
unnamed: R-PREPULSE-27.2, V-PREPULSE-3.4 (G3)
unnamed: R-PREPULSE-30.1, V-PREPULSE-6.7 (G1)
unnamed: R-PREPULSE-33.1, V-PREPULSE-3.7 (G1)
unnamed: R-PREPULSE-37.1, V-PREPULSE-4.7 (G1)

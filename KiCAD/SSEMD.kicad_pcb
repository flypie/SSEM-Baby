# Repository flypie/SSEM-Baby (continued)

## KiCad design KiCAD/SSEMD.kicad_pcb (continued)

Schematic: CRTPCIF2.sch, Control Gate Posn 6.3

Parts:
C-CRTPCIF2-1, C-CRTPCIF2-2, C-CRTPCIF2-3, C-CRTPCIF2-4, C-CRTPCIF2-5, C-CRTPCIF2-6: 22p; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-CRTPCIF2-7: 10000uf 16V; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-CRTPCIF2-8: 4u7 35V; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-CRTPCIF2-9, C-CRTPCIF2-12: 0.1; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-CRTPCIF2-10, C-CRTPCIF2-11: 4n7; C_Disc_D7.5mm_W5.0mm_P5.00mm
D-CRTPCIF2-1: EA50; Valve_B3G
D-CRTPCIF2-2, D-CRTPCIF2-3, D-CRTPCIF2-4, D-CRTPCIF2-5, D-CRTPCIF2-6, D-CRTPCIF2-7, D-CRTPCIF2-8, D-CRTPCIF2-9, D-CRTPCIF2-10, D-CRTPCIF2-11, D-CRTPCIF2-12, D-CRTPCIF2-13: CS60; D_T-1_P5.08mm_Horizontal
D-CRTPCIF2-14: IN4004; D_T-1_P5.08mm_Horizontal
D-CRTPCIF2-15: D_Tunnel; D_DO-201AD_P12.70mm_Horizontal
D-CRTPCIF2-16: IN4007; D_T-1_P5.08mm_Horizontal
J-ADDER1-18: HIGH Voltage.; TE_MATE-N-LOK_1-770970-x_2x04_P4.14mm_Horizontal
J-CRTPCIF2-1: PC.Read; 242431
J-CRTPCIF2-2, J-CRTPCIF2-3: A Read; 242431
J-CRTPCIF2-4: C4; 242431
J-CRTPCIF2-5: VAR.DASH.CF; 242431
J-CRTPCIF2-6: PC.UPLOAD; 242431
J-CRTPCIF2-7: CRT Blank; 242431
J-CRTPCIF2-8: Scope trigger; 242431
J-CRTPCIF2-9: S.ERASE.ALL; 242431
J-CRTPCIF2-10: PC.S.ERASE; 242431
J-CRTPCIF2-11: S Read; 242431
J-CRTPCIF2-12: DB25_Female_MountingHoles; DSUB-25_Female_Horizontal_P2.77x2.84mm_EdgePinOffset4.94mm_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
R-CRTPCIF2-1, R-CRTPCIF2-2, R-CRTPCIF2-3, R-CRTPCIF2-4, R-CRTPCIF2-5, R-CRTPCIF2-6: 100K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-CRTPCIF2-7, R-CRTPCIF2-8, R-CRTPCIF2-9, R-CRTPCIF2-10, R-CRTPCIF2-11, R-CRTPCIF2-12, R-CRTPCIF2-13, R-CRTPCIF2-14, R-CRTPCIF2-15: 10K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-CRTPCIF2-16: 4K7; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-CRTPCIF2-17, R-CRTPCIF2-18: 56K 2W; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-CRTPCIF2-19: 470K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-CRTPCIF2-20: 330K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-CRTPCIF2-21: 15K 3W; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-CRTPCIF2-22: 470; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
U1: L78L05_TO92; TO-92_Inline
U-CRTPCIF2-1, U-CRTPCIF2-4, U-CRTPCIF2-6: 4049; DIP-16_W7.62mm
U-CRTPCIF2-2: SN75188N; DIP794W53P254L1930H508Q14N; Manufacturer_Part_Number SN75188N; Mouser Part Number 595-SN75188N
U-CRTPCIF2-3: 4011; DIP-14_W7.62mm
U-CRTPCIF2-5: 4049; DIP-14_W7.62mm
V-CRTPCIF2-1, V-CRTPCIF2-2: VR91; Valve_9Loctal

Connections:
/CRTPCIF2/+8V: C-CRTPCIF2-7.1, C-CRTPCIF2-8.1, D-CRTPCIF2-14.1 (K), U1.3 (VI)
/CRTPCIF2/+200V: J-ADDER1-18.3, V-CRTPCIF2-2.2 (G2), V-CRTPCIF2-2.3 (A), V-CRTPCIF2-2.4 (G3)
/CRTPCIF2/+300V: J-ADDER1-18.4, R-CRTPCIF2-17.2, R-CRTPCIF2-18.2
/CRTPCIF2/-15V: D-CRTPCIF2-15.2 (A), R-CRTPCIF2-21.2
/CRTPCIF2/-150V: J-ADDER1-18.5, R-CRTPCIF2-20.1, R-CRTPCIF2-21.1
/CRTPCIF2/Ack: J-CRTPCIF2-12.10, U-CRTPCIF2-3.11
/CRTPCIF2/Bk1: C-CRTPCIF2-7.2, C-CRTPCIF2-8.2, C-CRTPCIF2-9.2, C-CRTPCIF2-10.2, C-CRTPCIF2-11.2, D-CRTPCIF2-1.1 (H), D-CRTPCIF2-1.2 (K), D-CRTPCIF2-3.2 (A), D-CRTPCIF2-5.2 (A), D-CRTPCIF2-7.2 (A), D-CRTPCIF2-9.2 (A), D-CRTPCIF2-11.2 (A), D-CRTPCIF2-13.2 (A), J-ADDER1-18.1, J-ADDER1-18.8, J-CRTPCIF2-12.23, J-CRTPCIF2-12.24, J-CRTPCIF2-12.25, U1.2 (GND), U-CRTPCIF2-1.8 (VSS), U-CRTPCIF2-2.7 (GND), U-CRTPCIF2-3.7 (VSS), U-CRTPCIF2-4.8 (VSS), U-CRTPCIF2-5.8 (Vss), U-CRTPCIF2-6.8 (GND), V-CRTPCIF2-1.4 (G3), V-CRTPCIF2-1.6 (K), V-CRTPCIF2-1.9 (H), V-CRTPCIF2-2.9 (F1)
/CRTPCIF2/Bn: J-CRTPCIF2-12.17, R-CRTPCIF2-12.1, U-CRTPCIF2-3.1, U-CRTPCIF2-3.5, U-CRTPCIF2-3.6
/CRTPCIF2/Busy: J-CRTPCIF2-12.11, U-CRTPCIF2-4.15
/CRTPCIF2/D0: J-CRTPCIF2-12.2, R-CRTPCIF2-15.2, U-CRTPCIF2-6.4 (D0)
/CRTPCIF2/D1: J-CRTPCIF2-12.3, R-CRTPCIF2-14.2, U-CRTPCIF2-6.5 (D1)
/CRTPCIF2/D2: J-CRTPCIF2-12.4, R-CRTPCIF2-13.2, U-CRTPCIF2-6.12 (D2)
/CRTPCIF2/D3: J-CRTPCIF2-12.5, R-CRTPCIF2-11.2, U-CRTPCIF2-6.13 (D3)
/CRTPCIF2/Err: J-CRTPCIF2-12.15, U-CRTPCIF2-5.6
/CRTPCIF2/Heater-6.3V: D-CRTPCIF2-1.3 (H), D-CRTPCIF2-14.2 (A), J-ADDER1-18.2, V-CRTPCIF2-1.1 (H), V-CRTPCIF2-2.1 (F1)
/CRTPCIF2/PE: J-CRTPCIF2-12.12, U-CRTPCIF2-5.2
/CRTPCIF2/S-Read-(buff'd): C-CRTPCIF2-3.2, R-CRTPCIF2-3.1, V-CRTPCIF2-2.6 (K)
/CRTPCIF2/SelectIn: J-CRTPCIF2-12.13, U-CRTPCIF2-4.12
/CRTPCIF2/VCC: C-CRTPCIF2-10.1, C-CRTPCIF2-11.1, D-CRTPCIF2-2.1 (K), D-CRTPCIF2-4.1 (K), D-CRTPCIF2-6.1 (K), D-CRTPCIF2-8.1 (K), D-CRTPCIF2-10.1 (K), D-CRTPCIF2-12.1 (K), D-CRTPCIF2-15.1 (K), R-CRTPCIF2-7.2, R-CRTPCIF2-8.2, R-CRTPCIF2-9.2, R-CRTPCIF2-10.2, R-CRTPCIF2-11.1, R-CRTPCIF2-12.2, R-CRTPCIF2-13.1, R-CRTPCIF2-14.1, R-CRTPCIF2-15.1, U1.1 (VO), U-CRTPCIF2-1.16 (VDD), U-CRTPCIF2-2.14 (VCC), U-CRTPCIF2-3.14 (VDD), U-CRTPCIF2-4.1 (VCC), U-CRTPCIF2-5.1 (Vdd), U-CRTPCIF2-6.1 (~Mr), U-CRTPCIF2-6.16 (VCC)
/CRTPCIF2/Y: C-CRTPCIF2-2.2, J-CRTPCIF2-3.1, R-CRTPCIF2-2.1
unnamed: C-CRTPCIF2-1.1, D-CRTPCIF2-6.2 (A), D-CRTPCIF2-7.1 (K), R-CRTPCIF2-1.2, R-CRTPCIF2-7.1, U-CRTPCIF2-3.2
unnamed: C-CRTPCIF2-1.2, J-CRTPCIF2-2.1, R-CRTPCIF2-1.1
unnamed: C-CRTPCIF2-2.1, D-CRTPCIF2-8.2 (A), D-CRTPCIF2-9.1 (K), R-CRTPCIF2-2.2, R-CRTPCIF2-8.1, U-CRTPCIF2-3.9
unnamed: C-CRTPCIF2-3.1, D-CRTPCIF2-10.2 (A), D-CRTPCIF2-11.1 (K), R-CRTPCIF2-3.2, R-CRTPCIF2-9.1, U-CRTPCIF2-4.11
unnamed: C-CRTPCIF2-4.1, D-CRTPCIF2-12.2 (A), D-CRTPCIF2-13.1 (K), R-CRTPCIF2-4.2, R-CRTPCIF2-10.1, U-CRTPCIF2-4.14
unnamed: C-CRTPCIF2-4.2, J-CRTPCIF2-1.1, R-CRTPCIF2-4.1
unnamed: C-CRTPCIF2-5.1, J-CRTPCIF2-4.1, R-CRTPCIF2-5.2
unnamed: C-CRTPCIF2-5.2, D-CRTPCIF2-2.2 (A), D-CRTPCIF2-3.1 (K), R-CRTPCIF2-5.1, U-CRTPCIF2-5.3
unnamed: C-CRTPCIF2-6.1, J-CRTPCIF2-5.1, R-CRTPCIF2-6.2
unnamed: C-CRTPCIF2-6.2, D-CRTPCIF2-4.2 (A), D-CRTPCIF2-5.1 (K), R-CRTPCIF2-6.1, U-CRTPCIF2-5.5
unnamed: C-CRTPCIF2-9.1, C-CRTPCIF2-12.1, R-CRTPCIF2-18.1, R-CRTPCIF2-19.2, V-CRTPCIF2-1.2 (G2)
unnamed: C-CRTPCIF2-12.2, D-CRTPCIF2-1.4 (A), D-CRTPCIF2-16.2 (A), J-CRTPCIF2-10.1, R-CRTPCIF2-19.1, R-CRTPCIF2-20.2
unnamed: D-CRTPCIF2-16.1 (K), J-CRTPCIF2-9.1
unnamed: J-CRTPCIF2-6.1, U-CRTPCIF2-2.6 (2Y)
unnamed: J-CRTPCIF2-7.1, U-CRTPCIF2-2.8 (3Y)
unnamed: J-CRTPCIF2-8.1, U-CRTPCIF2-2.3 (1Y)
unnamed: J-CRTPCIF2-11.1, R-CRTPCIF2-22.2
unnamed: R-CRTPCIF2-16.1, V-CRTPCIF2-1.7 (G1)
unnamed: R-CRTPCIF2-16.2, U-CRTPCIF2-2.11 (3Y)
unnamed: R-CRTPCIF2-17.1, V-CRTPCIF2-1.3 (A)
unnamed: R-CRTPCIF2-22.1, V-CRTPCIF2-2.7 (G1)
unnamed: U-CRTPCIF2-2.2 (1A), U-CRTPCIF2-6.11 (~Q2)
unnamed: U-CRTPCIF2-2.4 (2A), U-CRTPCIF2-5.4, U-CRTPCIF2-5.7, U-CRTPCIF2-6.9 (Cp)
unnamed: U-CRTPCIF2-2.5 (2B), U-CRTPCIF2-6.2 (Q0)
unnamed: U-CRTPCIF2-2.9 (3A), U-CRTPCIF2-2.10 (2B), U-CRTPCIF2-6.6 (~Q1)
unnamed: U-CRTPCIF2-2.12 (3A), U-CRTPCIF2-2.13 (2B), U-CRTPCIF2-6.14 (~Q3)
unnamed: U-CRTPCIF2-3.4, U-CRTPCIF2-3.8
unnamed: U-CRTPCIF2-3.10, U-CRTPCIF2-3.13
unnamed: U-CRTPCIF2-3.3, U-CRTPCIF2-3.12

Notes on the sheet:
CRT Erase

Schematic: DCHTRPU.sch, Control Adder Position 6.4

Parts:
C-DCHTRPU-1, C-DCHTRPU-2: C; C_Disc_D5.1mm_W3.2mm_P5.00mm
D-DCHTRPU-1: B250C3x00-2200A; Diode_Bridge_32.0x5.6x17.0mm_P10.0mm_P7.5mm
D-DCHTRPU-2: D_Zener; D_DO-34_SOD68_P7.62mm_Horizontal
LS1: Speaker; PinHeader_1x02_P2.54mm_Vertical
MES-DCHTRPU-1: Galvanometer; PinHeader_1x02_P2.54mm_Vertical
Q-DCHTRPU-1: Q_NPN_BCE; TO-3P-3_Vertical
R-DCHTRPU-1: R_Variable; R_Axial_DIN0411_L9.9mm_D3.6mm_P20.32mm_Horizontal
R-DCHTRPU-2: R; R_Axial_DIN0309_L9.0mm_D3.2mm_P15.24mm_Horizontal
R-DCHTRPU-3: R_Shunt; R_Shunt_Ohmite_LVK25
SW-DCHTRPU-1: SW_SPDT; PinHeader_1x03_P2.54mm_Vertical
T-AMPHTRTF--DCHTRPU-1: Transformer_1P_1S; FP12950

Connections:
/DCHTRPU/6V-DC: R-DCHTRPU-3.4, SW-DCHTRPU-1.1 (A)
/DCHTRPU/OV-DC: C-DCHTRPU-1.2, C-DCHTRPU-2.2, D-DCHTRPU-1.1 (-), Q-DCHTRPU-1.3 (E), R-DCHTRPU-2.2, SW-DCHTRPU-1.3 (C)
unnamed: C-DCHTRPU-1.1, C-DCHTRPU-2.1, D-DCHTRPU-2.2 (A), MES-DCHTRPU-1.2 (+), Q-DCHTRPU-1.2 (C), R-DCHTRPU-1.2, R-DCHTRPU-3.1
unnamed: D-DCHTRPU-1.2 (~~), T-AMPHTRTF--DCHTRPU-1.4 (SB)
unnamed: D-DCHTRPU-1.3 (~~), T-AMPHTRTF--DCHTRPU-1.3 (SA)
unnamed: D-DCHTRPU-1.4 (+), R-DCHTRPU-1.1
unnamed: D-DCHTRPU-2.1 (K), Q-DCHTRPU-1.1 (B), R-DCHTRPU-2.1
unnamed: MES-DCHTRPU-1.1 (-), SW-DCHTRPU-1.2 (B)

Notes on the sheet:
230V AC

Schematic: FSTAT13.sch, Control Gate Posn 6.3

Parts:
C-FSTAT13-1, C-FSTAT13-5, C-FSTAT13-6: 47p; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-FSTAT13-2, C-FSTAT13-3: 100p; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-FSTAT13-4, C-FSTAT13-7, C-FSTAT13-10: 0.1; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-FSTAT13-11, C-FSTAT13-13, C-FSTAT13-14, C-FSTAT13-15: 0.5; C_Disc_D7.5mm_W5.0mm_P5.00mm
D-FSTAT13-2, D-FSTAT13-3, D-FSTAT13-4, D-FSTAT13-5, D-FSTAT13-6, D-FSTAT13-7, D-FSTAT13-8, D-FSTAT13-9: EA50; Valve_B3G
J-FSTAT13-1: Fn13.0; 242431
J-FSTAT13-2: P13; 242431
J-FSTAT13-3: CI.13; 242431
J-FSTAT13-4: Ha; 242431
J-FSTAT13-5: Fn13.1; 242431
J-FSTAT13-13: FnS13.1; 242431
J-FSTAT13-14: FnS13.0; 242431
J-FSTAT13-17: HIGH Voltage.; TE_MATE-N-LOK_1-770970-x_2x04_P4.14mm_Horizontal
R-FSTAT13-1, R-FSTAT13-14, R-FSTAT13-29: 15K 6W; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-FSTAT13-2, R-FSTAT13-11, R-FSTAT13-23, R-FSTAT13-30: 470; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-FSTAT13-3, R-FSTAT13-22: 270K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-FSTAT13-4, R-FSTAT13-21, R-FSTAT13-24: 680K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-FSTAT13-5: 560K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-FSTAT13-6: 390K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-FSTAT13-7: 10K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-FSTAT13-8, R-FSTAT13-17, R-FSTAT13-18, R-FSTAT13-28: 47K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-FSTAT13-9, R-FSTAT13-16: 470K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-FSTAT13-10, R-FSTAT13-15: 15K 3W; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-FSTAT13-12, R-FSTAT13-13: 330K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-FSTAT13-19: 12K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-FSTAT13-20: 1M; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-FSTAT13-25: 27K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-FSTAT13-26: 39K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-FSTAT13-27: 4.7K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
V-FSTAT13-1, V-FSTAT13-2: VR91; Valve_9Loctal
V-FSTAT13-3, V-FSTAT13-4, V-FSTAT13-5, V-FSTAT13-6: CV173; Valve_9Loctal

Connections:
/FSTAT13/0V: C-FSTAT13-7.2, D-FSTAT13-6.2 (K), D-FSTAT13-7.2 (K), R-FSTAT13-26.1, R-FSTAT13-27.2, V-FSTAT13-1.6 (K), V-FSTAT13-2.6 (K)
/FSTAT13/+50V: C-FSTAT13-15.1, J-FSTAT13-17.6
/FSTAT13/+118V: D-FSTAT13-4.2 (K), D-FSTAT13-8.2 (K)
/FSTAT13/+200V: C-FSTAT13-13.1, J-FSTAT13-17.3, R-FSTAT13-25.2, V-FSTAT13-3.2 (G2), V-FSTAT13-3.3 (A), V-FSTAT13-3.4 (G3), V-FSTAT13-4.2 (G2), V-FSTAT13-4.3 (A), V-FSTAT13-4.4 (G3), V-FSTAT13-5.2 (G2), V-FSTAT13-5.3 (A), V-FSTAT13-5.4 (G3), V-FSTAT13-6.2 (G2), V-FSTAT13-6.3 (A), V-FSTAT13-6.4 (G3)
/FSTAT13/+300V: C-FSTAT13-11.1, J-FSTAT13-17.4, R-FSTAT13-6.1, R-FSTAT13-8.1, R-FSTAT13-17.1, R-FSTAT13-19.1, R-FSTAT13-20.2
/FSTAT13/-14V: C-FSTAT13-10.1, D-FSTAT13-5.4 (A), D-FSTAT13-9.4 (A), R-FSTAT13-27.1, R-FSTAT13-28.2
/FSTAT13/-150V: C-FSTAT13-10.2, C-FSTAT13-14.2, J-FSTAT13-17.5, R-FSTAT13-13.2, R-FSTAT13-14.2, R-FSTAT13-21.1, R-FSTAT13-24.1, R-FSTAT13-28.1, R-FSTAT13-29.2
/FSTAT13/GND: C-FSTAT13-4.2, C-FSTAT13-11.2, C-FSTAT13-13.2, C-FSTAT13-14.1, C-FSTAT13-15.2, J-FSTAT13-17.8
/FSTAT13/Heater-6.3V: D-FSTAT13-2.1 (H), D-FSTAT13-3.1 (H), D-FSTAT13-4.1 (H), D-FSTAT13-5.1 (H), D-FSTAT13-6.1 (H), D-FSTAT13-7.1 (H), D-FSTAT13-8.1 (H), D-FSTAT13-9.1 (H), J-FSTAT13-17.2, V-FSTAT13-1.9 (H), V-FSTAT13-2.9 (H), V-FSTAT13-3.9 (F1), V-FSTAT13-4.9 (H), V-FSTAT13-5.9 (H), V-FSTAT13-6.9 (H)
/FSTAT13/Heater-GND: D-FSTAT13-2.3 (H), D-FSTAT13-3.3 (H), D-FSTAT13-4.3 (H), D-FSTAT13-5.3 (H), D-FSTAT13-6.3 (H), D-FSTAT13-7.3 (H), D-FSTAT13-8.3 (H), D-FSTAT13-9.3 (H), J-FSTAT13-17.1, V-FSTAT13-1.1 (H), V-FSTAT13-2.1 (H), V-FSTAT13-3.1 (F1), V-FSTAT13-4.1 (H), V-FSTAT13-5.1 (H), V-FSTAT13-6.1 (H)
unnamed: C-FSTAT13-1.1, C-FSTAT13-2.2, R-FSTAT13-3.2, R-FSTAT13-8.2, R-FSTAT13-9.1, V-FSTAT13-1.3 (A)
unnamed: C-FSTAT13-1.2, D-FSTAT13-8.4 (A), D-FSTAT13-9.2 (K), R-FSTAT13-2.1, R-FSTAT13-3.1, R-FSTAT13-4.2
unnamed: C-FSTAT13-2.1, D-FSTAT13-6.4 (A), R-FSTAT13-9.2, R-FSTAT13-13.1, R-FSTAT13-15.2, R-FSTAT13-30.1
unnamed: C-FSTAT13-3.1, D-FSTAT13-7.4 (A), R-FSTAT13-10.2, R-FSTAT13-11.1, R-FSTAT13-12.1, R-FSTAT13-16.2
unnamed: C-FSTAT13-3.2, C-FSTAT13-6.1, R-FSTAT13-16.1, R-FSTAT13-17.2, R-FSTAT13-22.2, V-FSTAT13-2.3 (A)
unnamed: C-FSTAT13-4.1, R-FSTAT13-19.2, V-FSTAT13-2.2 (G2)
unnamed: C-FSTAT13-5.1, R-FSTAT13-18.1, R-FSTAT13-20.1
unnamed: C-FSTAT13-5.2, J-FSTAT13-4.1
unnamed: C-FSTAT13-6.2, D-FSTAT13-4.4 (A), D-FSTAT13-5.2 (K), R-FSTAT13-21.2, R-FSTAT13-22.1, R-FSTAT13-23.2
unnamed: C-FSTAT13-7.1, R-FSTAT13-25.1, R-FSTAT13-26.2
unnamed: D-FSTAT13-2.2 (K), D-FSTAT13-3.2 (K), R-FSTAT13-5.2, R-FSTAT13-7.1
unnamed: D-FSTAT13-2.4 (A), J-FSTAT13-2.1
unnamed: D-FSTAT13-3.4 (A), J-FSTAT13-3.1, R-FSTAT13-6.2
unnamed: J-FSTAT13-1.1, R-FSTAT13-1.2, V-FSTAT13-4.6 (K)
unnamed: J-FSTAT13-5.1, R-FSTAT13-24.2, V-FSTAT13-3.6 (K)
unnamed: J-FSTAT13-13.1, R-FSTAT13-29.1, V-FSTAT13-6.6 (K)
unnamed: J-FSTAT13-14.1, R-FSTAT13-14.1, V-FSTAT13-5.6 (K)
unnamed: R-FSTAT13-1.1, R-FSTAT13-4.1, R-FSTAT13-5.1, R-FSTAT13-12.2
unnamed: R-FSTAT13-2.2, V-FSTAT13-4.7 (G1)
unnamed: R-FSTAT13-7.2, V-FSTAT13-1.7 (G1)
unnamed: R-FSTAT13-10.1, V-FSTAT13-1.4 (G3)
unnamed: R-FSTAT13-11.2, V-FSTAT13-6.7 (G1)
unnamed: R-FSTAT13-15.1, V-FSTAT13-2.4 (G3)
unnamed: R-FSTAT13-18.2, V-FSTAT13-2.7 (G1)
unnamed: R-FSTAT13-23.1, V-FSTAT13-3.7 (G1)
unnamed: R-FSTAT13-30.2, V-FSTAT13-5.7 (G1)

Notes on the sheet:
+10V/-60V
+110V/-10V

Schematic: FSTAT14.sch, Control Gate Posn 6.3

Parts:
C-FSTAT14-1, C-FSTAT14-5, C-FSTAT14-6: 47p; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-FSTAT14-2, C-FSTAT14-3: 100p; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-FSTAT14-4, C-FSTAT14-7, C-FSTAT14-8: 0.1; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-FSTAT14-13, C-FSTAT14-14, C-FSTAT14-15, C-FSTAT14-16: 0.5; C_Disc_D7.5mm_W5.0mm_P5.00mm
D-FSTAT14-1, D-FSTAT14-2, D-FSTAT14-3, D-FSTAT14-4, D-FSTAT14-5, D-FSTAT14-6, D-FSTAT14-7, D-FSTAT14-8: EA50; Valve_B3G
J-FSTAT14-1: Fn13.0; 242431
J-FSTAT14-2: P13; 242431
J-FSTAT14-3: CI.13; 242431
J-FSTAT14-4: FnS13.1; 242431
J-FSTAT14-5: FnS13.0; 242431
J-FSTAT14-6: Ha; 242431
J-FSTAT14-7: Fn13.1; 242431
J-FSTAT14-17: HIGH Voltage.; TE_MATE-N-LOK_1-770970-x_2x04_P4.14mm_Horizontal
R-FSTAT14-1, R-FSTAT14-11, R-FSTAT14-16: 15K 6W; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-FSTAT14-2, R-FSTAT14-12, R-FSTAT14-15, R-FSTAT14-25: 470; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-FSTAT14-3, R-FSTAT14-24: 270K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-FSTAT14-4, R-FSTAT14-23, R-FSTAT14-26: 680K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-FSTAT14-5: 560K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-FSTAT14-6: 390K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-FSTAT14-7: 10K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-FSTAT14-8, R-FSTAT14-19, R-FSTAT14-20, R-FSTAT14-30: 47K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-FSTAT14-9, R-FSTAT14-18: 470K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-FSTAT14-10, R-FSTAT14-17: 15K 3W; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-FSTAT14-13, R-FSTAT14-14: 330K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-FSTAT14-21: 12K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-FSTAT14-22: 1M; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-FSTAT14-27: 27K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-FSTAT14-28: 39K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-FSTAT14-29: 4.7K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
V-FSTAT14-1, V-FSTAT14-4, V-FSTAT14-5, V-FSTAT14-6, V-FSTAT14-7, V-FSTAT14-8, V-FSTAT14-9, V-FSTAT14-10: CV173; Valve_9Loctal
V-FSTAT14-2, V-FSTAT14-3: VR91; Valve_9Loctal

Connections:
/FSTAT14/0V: C-FSTAT14-8.2, D-FSTAT14-5.2 (K), D-FSTAT14-6.2 (K), R-FSTAT14-28.1, R-FSTAT14-29.2, V-FSTAT14-2.6 (K), V-FSTAT14-3.6 (K)
/FSTAT14/+50V: C-FSTAT14-15.1, J-FSTAT14-17.6
/FSTAT14/+118V: D-FSTAT14-1.2 (K), D-FSTAT14-7.2 (K)
/FSTAT14/+200V: C-FSTAT14-13.1, J-FSTAT14-17.3, R-FSTAT14-27.2, V-FSTAT14-1.2 (G2), V-FSTAT14-1.3 (A), V-FSTAT14-1.4 (G3), V-FSTAT14-8.2 (G2), V-FSTAT14-8.3 (A), V-FSTAT14-8.4 (G3), V-FSTAT14-9.2 (G2), V-FSTAT14-9.3 (A), V-FSTAT14-9.4 (G3), V-FSTAT14-10.2 (G2), V-FSTAT14-10.3 (A), V-FSTAT14-10.4 (G3)
/FSTAT14/+300V: C-FSTAT14-16.1, J-FSTAT14-17.4, R-FSTAT14-6.1, R-FSTAT14-8.1, R-FSTAT14-19.1, R-FSTAT14-21.1, R-FSTAT14-22.2
/FSTAT14/-14V: C-FSTAT14-7.1, D-FSTAT14-2.4 (A), D-FSTAT14-8.4 (A), R-FSTAT14-29.1, R-FSTAT14-30.2
/FSTAT14/-150V: C-FSTAT14-7.2, C-FSTAT14-14.2, J-FSTAT14-17.5, R-FSTAT14-11.2, R-FSTAT14-14.2, R-FSTAT14-16.2, R-FSTAT14-23.1, R-FSTAT14-26.1, R-FSTAT14-30.1
/FSTAT14/GND: C-FSTAT14-4.2, C-FSTAT14-13.2, C-FSTAT14-14.1, C-FSTAT14-15.2, C-FSTAT14-16.2, J-FSTAT14-17.8
/FSTAT14/Heater-6.3V: D-FSTAT14-1.1 (H), D-FSTAT14-2.1 (H), D-FSTAT14-3.1 (H), D-FSTAT14-4.1 (H), D-FSTAT14-5.1 (H), D-FSTAT14-6.1 (H), D-FSTAT14-7.1 (H), D-FSTAT14-8.1 (H), J-FSTAT14-17.2, V-FSTAT14-2.9 (H), V-FSTAT14-3.9 (H), V-FSTAT14-4.9 (H), V-FSTAT14-5.9 (H), V-FSTAT14-6.9 (H), V-FSTAT14-7.9 (H)
/FSTAT14/Heater-GND: D-FSTAT14-1.3 (H), D-FSTAT14-2.3 (H), D-FSTAT14-3.3 (H), D-FSTAT14-4.3 (H), D-FSTAT14-5.3 (H), D-FSTAT14-6.3 (H), D-FSTAT14-7.3 (H), D-FSTAT14-8.3 (H), J-FSTAT14-17.1, V-FSTAT14-2.1 (H), V-FSTAT14-3.1 (H), V-FSTAT14-4.1 (H), V-FSTAT14-5.1 (H), V-FSTAT14-6.1 (H), V-FSTAT14-7.1 (H)
unnamed: C-FSTAT14-1.1, C-FSTAT14-2.2, R-FSTAT14-3.2, R-FSTAT14-8.2, R-FSTAT14-9.1, V-FSTAT14-2.3 (A)
unnamed: C-FSTAT14-1.2, D-FSTAT14-1.4 (A), D-FSTAT14-2.2 (K), R-FSTAT14-2.1, R-FSTAT14-3.1, R-FSTAT14-4.2
unnamed: C-FSTAT14-2.1, D-FSTAT14-6.4 (A), R-FSTAT14-9.2, R-FSTAT14-14.1, R-FSTAT14-15.1, R-FSTAT14-17.2
unnamed: C-FSTAT14-3.1, D-FSTAT14-5.4 (A), R-FSTAT14-10.2, R-FSTAT14-12.1, R-FSTAT14-13.1, R-FSTAT14-18.2
unnamed: C-FSTAT14-3.2, C-FSTAT14-6.1, R-FSTAT14-18.1, R-FSTAT14-19.2, R-FSTAT14-24.2, V-FSTAT14-3.3 (A)
unnamed: C-FSTAT14-4.1, R-FSTAT14-21.2, V-FSTAT14-3.2 (G2)
unnamed: C-FSTAT14-5.1, R-FSTAT14-20.1, R-FSTAT14-22.1
unnamed: C-FSTAT14-5.2, J-FSTAT14-6.1
unnamed: C-FSTAT14-6.2, D-FSTAT14-7.4 (A), D-FSTAT14-8.2 (K), R-FSTAT14-23.2, R-FSTAT14-24.1, R-FSTAT14-25.2
unnamed: C-FSTAT14-8.1, R-FSTAT14-27.1, R-FSTAT14-28.2
unnamed: D-FSTAT14-3.2 (K), D-FSTAT14-4.2 (K), R-FSTAT14-5.2, R-FSTAT14-7.1
unnamed: D-FSTAT14-3.4 (A), J-FSTAT14-2.1
unnamed: D-FSTAT14-4.4 (A), J-FSTAT14-3.1, R-FSTAT14-6.2
unnamed: J-FSTAT14-1.1, R-FSTAT14-1.2, V-FSTAT14-1.6 (K)
unnamed: J-FSTAT14-4.1, R-FSTAT14-11.1, V-FSTAT14-8.6 (K)
unnamed: J-FSTAT14-5.1, R-FSTAT14-16.1, V-FSTAT14-9.6 (K)
unnamed: J-FSTAT14-7.1, R-FSTAT14-26.2, V-FSTAT14-10.6 (K)
unnamed: R-FSTAT14-1.1, R-FSTAT14-4.1, R-FSTAT14-5.1, R-FSTAT14-13.2
unnamed: R-FSTAT14-2.2, V-FSTAT14-1.7 (G1)
unnamed: R-FSTAT14-7.2, V-FSTAT14-2.7 (G1)
unnamed: R-FSTAT14-10.1, V-FSTAT14-2.4 (G3)
unnamed: R-FSTAT14-12.2, V-FSTAT14-8.7 (G1)
unnamed: R-FSTAT14-15.2, V-FSTAT14-9.7 (G1)
unnamed: R-FSTAT14-17.1, V-FSTAT14-3.4 (G3)
unnamed: R-FSTAT14-20.2, V-FSTAT14-3.7 (G1)
unnamed: R-FSTAT14-25.1, V-FSTAT14-10.7 (G1)

Notes on the sheet:
+10V/-60V
+110V/-10V

Schematic: FSTAT15.sch, Control Gate Posn 6.3

Parts:
C-FSTAT15-1, C-FSTAT15-8, C-FSTAT15-9: 47p; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-FSTAT15-2, C-FSTAT15-4: 100p; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-FSTAT15-3, C-FSTAT15-5, C-FSTAT15-6, C-FSTAT15--A-1: 0.5; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-FSTAT15-7, C-FSTAT15-10, C-FSTAT15-11: 0.1; C_Disc_D7.5mm_W5.0mm_P5.00mm
D-FSTAT15-1, D-FSTAT15-2, D-FSTAT15-3, D-FSTAT15-4, D-FSTAT15-5, D-FSTAT15-6, D-FSTAT15-7, D-FSTAT15-8: EA50; Valve_B3G
J-FSTAT15-1: Fn13.0; 242431
J-FSTAT15-2: HIGH Voltage.; TE_MATE-N-LOK_1-770970-x_2x04_P4.14mm_Horizontal
J-FSTAT15-3: P13; 242431
J-FSTAT15-4: CI.13; 242431
J-FSTAT15-5: FnS13.1; 242431
J-FSTAT15-6: FnS13.0; 242431
J-FSTAT15-7: Ha; 242431
J-FSTAT15-8: Fn13.1; 242431
R-FSTAT15-1, R-FSTAT15-11, R-FSTAT15-16: 15K 6W; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-FSTAT15-2, R-FSTAT15-12, R-FSTAT15-15, R-FSTAT15-25: 470; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-FSTAT15-3, R-FSTAT15-24: 270K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-FSTAT15-4, R-FSTAT15-23, R-FSTAT15-26: 680K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-FSTAT15-5: 560K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-FSTAT15-6: 390K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-FSTAT15-7: 10K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-FSTAT15-8, R-FSTAT15-19, R-FSTAT15-20, R-FSTAT15-30: 47K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-FSTAT15-9, R-FSTAT15-18: 470K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-FSTAT15-10, R-FSTAT15-17: 15K 3W; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-FSTAT15-13, R-FSTAT15-14: 330K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-FSTAT15-21: 12K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-FSTAT15-22: 1M; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-FSTAT15-27: 27K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-FSTAT15-28: 39K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-FSTAT15-29: 4.7K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
V-FSTAT15-1, V-FSTAT15-5, V-FSTAT15-7, V-FSTAT15-8, V-FSTAT15-9, V-FSTAT15-10: CV173; Valve_9Loctal
V-FSTAT15-2, V-FSTAT15-3, V-FSTAT15-4, V-FSTAT15-6: VR91; Valve_9Loctal

Connections:
/FSTAT15/0V: C-FSTAT15-11.2, D-FSTAT15-5.2 (K), D-FSTAT15-6.2 (K), R-FSTAT15-28.1, R-FSTAT15-29.2, V-FSTAT15-2.6 (K), V-FSTAT15-3.6 (K)
/FSTAT15/+50V: C-FSTAT15-6.1, J-FSTAT15-2.6
/FSTAT15/+118V: D-FSTAT15-1.2 (K), D-FSTAT15-7.2 (K)
/FSTAT15/+200V: C-FSTAT15-3.1, J-FSTAT15-2.3, R-FSTAT15-27.2, V-FSTAT15-1.2 (G2), V-FSTAT15-1.3 (A), V-FSTAT15-1.4 (G3), V-FSTAT15-8.2 (G2), V-FSTAT15-8.3 (A), V-FSTAT15-8.4 (G3), V-FSTAT15-9.2 (G2), V-FSTAT15-9.3 (A), V-FSTAT15-9.4 (G3), V-FSTAT15-10.2 (G2), V-FSTAT15-10.3 (A), V-FSTAT15-10.4 (G3)
/FSTAT15/+300V: C-FSTAT15--A-1.1, J-FSTAT15-2.4, R-FSTAT15-6.1, R-FSTAT15-8.1, R-FSTAT15-19.1, R-FSTAT15-21.1, R-FSTAT15-22.2
/FSTAT15/-14V: C-FSTAT15-10.1, D-FSTAT15-2.4 (A), D-FSTAT15-8.4 (A), R-FSTAT15-29.1, R-FSTAT15-30.2
/FSTAT15/-150V: C-FSTAT15-5.2, C-FSTAT15-10.2, J-FSTAT15-2.5, R-FSTAT15-11.2, R-FSTAT15-14.2, R-FSTAT15-16.2, R-FSTAT15-23.1, R-FSTAT15-26.1, R-FSTAT15-30.1
/FSTAT15/GND: C-FSTAT15-3.2, C-FSTAT15-5.1, C-FSTAT15-6.2, C-FSTAT15-7.2, C-FSTAT15--A-1.2, J-FSTAT15-2.8
/FSTAT15/Heater-6.3V: D-FSTAT15-1.1 (H), D-FSTAT15-2.1 (H), D-FSTAT15-3.1 (H), D-FSTAT15-4.1 (H), D-FSTAT15-5.1 (H), D-FSTAT15-6.1 (H), D-FSTAT15-7.1 (H), D-FSTAT15-8.1 (H), J-FSTAT15-2.2, V-FSTAT15-2.9 (H), V-FSTAT15-3.9 (H), V-FSTAT15-4.9 (H), V-FSTAT15-5.9 (H), V-FSTAT15-6.9 (H), V-FSTAT15-7.9 (H)
/FSTAT15/Heater-GND: D-FSTAT15-1.3 (H), D-FSTAT15-2.3 (H), D-FSTAT15-3.3 (H), D-FSTAT15-4.3 (H), D-FSTAT15-5.3 (H), D-FSTAT15-6.3 (H), D-FSTAT15-7.3 (H), D-FSTAT15-8.3 (H), J-FSTAT15-2.1, V-FSTAT15-2.1 (H), V-FSTAT15-3.1 (H), V-FSTAT15-4.1 (H), V-FSTAT15-5.1 (H), V-FSTAT15-6.1 (H), V-FSTAT15-7.1 (H)
unnamed: C-FSTAT15-1.1, C-FSTAT15-2.2, R-FSTAT15-3.2, R-FSTAT15-8.2, R-FSTAT15-9.1, V-FSTAT15-2.3 (A)
unnamed: C-FSTAT15-1.2, D-FSTAT15-1.4 (A), D-FSTAT15-2.2 (K), R-FSTAT15-2.1, R-FSTAT15-3.1, R-FSTAT15-4.2
unnamed: C-FSTAT15-2.1, D-FSTAT15-6.4 (A), R-FSTAT15-9.2, R-FSTAT15-14.1, R-FSTAT15-15.1, R-FSTAT15-17.2
unnamed: C-FSTAT15-4.1, D-FSTAT15-5.4 (A), R-FSTAT15-10.2, R-FSTAT15-12.1, R-FSTAT15-13.1, R-FSTAT15-18.2
unnamed: C-FSTAT15-4.2, C-FSTAT15-9.1, R-FSTAT15-18.1, R-FSTAT15-19.2, R-FSTAT15-24.2, V-FSTAT15-3.3 (A)
unnamed: C-FSTAT15-7.1, R-FSTAT15-21.2, V-FSTAT15-3.2 (G2)
unnamed: C-FSTAT15-8.1, R-FSTAT15-20.1, R-FSTAT15-22.1
unnamed: C-FSTAT15-8.2, J-FSTAT15-7.1
unnamed: C-FSTAT15-9.2, D-FSTAT15-7.4 (A), D-FSTAT15-8.2 (K), R-FSTAT15-23.2, R-FSTAT15-24.1, R-FSTAT15-25.2
unnamed: C-FSTAT15-11.1, R-FSTAT15-27.1, R-FSTAT15-28.2
unnamed: D-FSTAT15-3.2 (K), D-FSTAT15-4.2 (K), R-FSTAT15-5.2, R-FSTAT15-7.1
unnamed: D-FSTAT15-3.4 (A), J-FSTAT15-3.1
unnamed: D-FSTAT15-4.4 (A), J-FSTAT15-4.1, R-FSTAT15-6.2
unnamed: J-FSTAT15-1.1, R-FSTAT15-1.2, V-FSTAT15-1.6 (K)
unnamed: J-FSTAT15-5.1, R-FSTAT15-11.1, V-FSTAT15-8.6 (K)
unnamed: J-FSTAT15-6.1, R-FSTAT15-16.1, V-FSTAT15-9.6 (K)
unnamed: J-FSTAT15-8.1, R-FSTAT15-26.2, V-FSTAT15-10.6 (K)
unnamed: R-FSTAT15-1.1, R-FSTAT15-4.1, R-FSTAT15-5.1, R-FSTAT15-13.2
unnamed: R-FSTAT15-2.2, V-FSTAT15-1.7 (G1)
unnamed: R-FSTAT15-7.2, V-FSTAT15-2.7 (G1)
unnamed: R-FSTAT15-10.1, V-FSTAT15-2.4 (G3)
unnamed: R-FSTAT15-12.2, V-FSTAT15-8.7 (G1)
unnamed: R-FSTAT15-15.2, V-FSTAT15-9.7 (G1)
unnamed: R-FSTAT15-17.1, V-FSTAT15-3.4 (G3)
unnamed: R-FSTAT15-20.2, V-FSTAT15-3.7 (G1)
unnamed: R-FSTAT15-25.1, V-FSTAT15-10.7 (G1)

Notes on the sheet:
+10V/-60V
+110V/-10V

Schematic: IGYSH3.sch, Instruction Gate & Y Shift Position 4.1

Parts:
C-IGYSH3-1, C-IGYSH3-8: 470p; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-IGYSH3-2, C-IGYSH3-4, C-IGYSH3-9, C-IGYSH3-11, C-IGYSH3-13, C-IGYSH3-14: 100p; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-IGYSH3-3, C-IGYSH3-5, C-IGYSH3-6, C-IGYSH3--A-1: 0.5; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-IGYSH3-7, C-IGYSH3-12, C-IGYSH3-17: 47p; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-IGYSH3-10: 10pF; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-IGYSH3-15, C-IGYSH3-16: 0.001; C_Disc_D7.5mm_W5.0mm_P5.00mm
D-IGYSH3-1, D-IGYSH3-2, D-IGYSH3-3, D-IGYSH3-4, D-IGYSH3-5, D-IGYSH3-6, D-IGYSH3-7, D-IGYSH3-8, D-IGYSH3-9, D-IGYSH3-10: EA50; Valve_B3G
J-IGYSH3-1: Completion; 242431
J-IGYSH3-2: HIGH Voltage.; TE_MATE-N-LOK_1-770970-x_2x04_P4.14mm_Horizontal
J-IGYSH3-3: Hs; 242431
J-IGYSH3-4: Inst.Gate; 242431
J-IGYSH3-5: CL Y Shift; 242431
J-IGYSH3-6: C.Y1; 242431
J-IGYSH3-7: C.Y2; 242431
J-IGYSH3-8: Action.Trigger; 242431
R-IGYSH3-1, R-IGYSH3-19, R-IGYSH3-30: 1M; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-IGYSH3-2, R-IGYSH3-22, R-IGYSH3-36, R-IGYSH3-48: 10K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-IGYSH3-3, R-IGYSH3-15, R-IGYSH3-23, R-IGYSH3-37: 56K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-IGYSH3-4: 5M6; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-IGYSH3-5, R-IGYSH3-14, R-IGYSH3-24, R-IGYSH3-25, R-IGYSH3-35: 470K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-IGYSH3-6, R-IGYSH3-12, R-IGYSH3-33: 15K 6W; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-IGYSH3-7, R-IGYSH3-8, R-IGYSH3-11, R-IGYSH3-13, R-IGYSH3-17, R-IGYSH3-20, R-IGYSH3-26, R-IGYSH3-31, R-IGYSH3-34, R-IGYSH3-39, R-IGYSH3-47: 470; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-IGYSH3-9, R-IGYSH3-10, R-IGYSH3-27, R-IGYSH3-32: 330K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-IGYSH3-16, R-IGYSH3-38: 12K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-IGYSH3-18, R-IGYSH3-40: 1.2M; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-IGYSH3-21: 80K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-IGYSH3-28: 150K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-IGYSH3-29: 820K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-IGYSH3-41, R-IGYSH3-43: 47K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-IGYSH3-42, R-IGYSH3-44: 1.2K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-IGYSH3-45: 100K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-IGYSH3-46: 82K 1W; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
RV-IGYSH3-1: 10K; Potentiometer_Bourns_3339P_Vertical_HandSoldering
RV-IGYSH3-2: 150K; Potentiometer_Bourns_3339P_Vertical_HandSoldering
RV-IGYSH3-3: 300K; Potentiometer_Bourns_3339P_Vertical_HandSoldering
SW-IGYSH3-1: SW_SPST; PinHeader_1x02_P2.54mm_Vertical
V-IGYSH3-1, V-IGYSH3-2, V-IGYSH3-3, V-IGYSH3-4, V-IGYSH3-6, V-IGYSH3-8: VR91; Valve_9Loctal
V-IGYSH3-5, V-IGYSH3-7: CV173; Valve_9Loctal

Connections:
/IGYSH3/+50V: C-IGYSH3-6.1, J-IGYSH3-2.6
/IGYSH3/+200V: C-IGYSH3-3.1, D-IGYSH3-6.2 (K), J-IGYSH3-2.3, RV-IGYSH3-1.1, V-IGYSH3-5.2 (G2), V-IGYSH3-5.3 (A), V-IGYSH3-5.4 (G3), V-IGYSH3-6.2 (G2), V-IGYSH3-6.3 (A), V-IGYSH3-6.4 (G3), V-IGYSH3-7.2 (G2), V-IGYSH3-7.3 (A), V-IGYSH3-7.4 (G3), V-IGYSH3-8.2 (G2), V-IGYSH3-8.3 (A), V-IGYSH3-8.4 (G3)
/IGYSH3/+300V: C-IGYSH3--A-1.1, J-IGYSH3-2.4, R-IGYSH3-1.2, R-IGYSH3-3.1, R-IGYSH3-4.2, R-IGYSH3-15.1, R-IGYSH3-16.1, R-IGYSH3-18.1, R-IGYSH3-19.2, R-IGYSH3-22.1, R-IGYSH3-25.2, R-IGYSH3-36.1, R-IGYSH3-38.1, R-IGYSH3-40.1, R-IGYSH3-45.1, R-IGYSH3-46.1, RV-IGYSH3-3.1
/IGYSH3/-150V: C-IGYSH3-5.2, J-IGYSH3-2.5, R-IGYSH3-6.2, R-IGYSH3-9.2, R-IGYSH3-10.2, R-IGYSH3-12.2, R-IGYSH3-27.2, R-IGYSH3-32.2, R-IGYSH3-33.1, R-IGYSH3-48.1, RV-IGYSH3-2.3
/IGYSH3/GND: C-IGYSH3-3.2, C-IGYSH3-5.1, C-IGYSH3-6.2, C-IGYSH3-15.2, C-IGYSH3-16.2, C-IGYSH3-17.2, C-IGYSH3--A-1.2, D-IGYSH3-3.2 (K), D-IGYSH3-4.2 (K), D-IGYSH3-7.2 (K), D-IGYSH3-8.2 (K), J-IGYSH3-2.8, R-IGYSH3-21.2, R-IGYSH3-44.2, RV-IGYSH3-2.1, RV-IGYSH3-3.3, V-IGYSH3-1.6 (K), V-IGYSH3-2.6 (K), V-IGYSH3-3.6 (K), V-IGYSH3-4.6 (K)
/IGYSH3/Heater-6.3V: D-IGYSH3-1.1 (H), D-IGYSH3-2.1 (H), D-IGYSH3-3.1 (H), D-IGYSH3-4.1 (H), D-IGYSH3-5.1 (H), D-IGYSH3-6.1 (H), D-IGYSH3-7.1 (H), D-IGYSH3-8.1 (H), D-IGYSH3-9.1 (H), D-IGYSH3-10.1 (H), J-IGYSH3-2.2, V-IGYSH3-1.9 (H), V-IGYSH3-2.9 (H), V-IGYSH3-3.9 (H), V-IGYSH3-4.9 (H), V-IGYSH3-5.9 (F1), V-IGYSH3-6.9 (H), V-IGYSH3-7.9 (F1), V-IGYSH3-8.9 (H)
/IGYSH3/Heater-GND: D-IGYSH3-1.3 (H), D-IGYSH3-2.3 (H), D-IGYSH3-3.3 (H), D-IGYSH3-4.3 (H), D-IGYSH3-5.3 (H), D-IGYSH3-6.3 (H), D-IGYSH3-7.3 (H), D-IGYSH3-8.3 (H), D-IGYSH3-9.3 (H), D-IGYSH3-10.3 (H), J-IGYSH3-2.1, V-IGYSH3-1.1 (H), V-IGYSH3-2.1 (H), V-IGYSH3-3.1 (H), V-IGYSH3-4.1 (H), V-IGYSH3-5.1 (F1), V-IGYSH3-6.1 (H), V-IGYSH3-7.1 (F1), V-IGYSH3-8.1 (H)
unnamed: C-IGYSH3-1.1, R-IGYSH3-1.1, R-IGYSH3-2.1
unnamed: C-IGYSH3-1.2, J-IGYSH3-1.1
unnamed: C-IGYSH3-2.1, D-IGYSH3-4.4 (A), R-IGYSH3-5.2, R-IGYSH3-10.1, R-IGYSH3-13.2
unnamed: C-IGYSH3-2.2, C-IGYSH3-8.2, R-IGYSH3-3.2, R-IGYSH3-5.1, V-IGYSH3-1.3 (A)
unnamed: C-IGYSH3-4.1, D-IGYSH3-3.4 (A), D-IGYSH3-9.2 (K), R-IGYSH3-8.2, R-IGYSH3-9.1, R-IGYSH3-14.2
unnamed: C-IGYSH3-4.2, R-IGYSH3-14.1, R-IGYSH3-15.2, V-IGYSH3-2.3 (A)
unnamed: C-IGYSH3-7.1, J-IGYSH3-3.1
unnamed: C-IGYSH3-8.1, R-IGYSH3-19.1, R-IGYSH3-20.1
unnamed: C-IGYSH3-9.1, D-IGYSH3-8.4 (A), R-IGYSH3-24.2, R-IGYSH3-32.1, R-IGYSH3-34.2
unnamed: C-IGYSH3-9.2, R-IGYSH3-23.2, R-IGYSH3-24.1, R-IGYSH3-28.2, V-IGYSH3-3.3 (A)
unnamed: C-IGYSH3-10.1, D-IGYSH3-5.2 (K), D-IGYSH3-6.4 (A), R-IGYSH3-25.1, R-IGYSH3-28.1, R-IGYSH3-29.2
unnamed: C-IGYSH3-10.2, R-IGYSH3-29.1, R-IGYSH3-30.2, R-IGYSH3-31.1
unnamed: C-IGYSH3-11.1, D-IGYSH3-7.4 (A), D-IGYSH3-10.2 (K), R-IGYSH3-11.1, R-IGYSH3-26.2, R-IGYSH3-27.1, R-IGYSH3-35.2
unnamed: C-IGYSH3-11.2, R-IGYSH3-35.1, R-IGYSH3-37.2, V-IGYSH3-4.3 (A)
unnamed: C-IGYSH3-7.2, C-IGYSH3-12.1, R-IGYSH3-17.1, R-IGYSH3-18.2
unnamed: C-IGYSH3-12.2, R-IGYSH3-39.1, R-IGYSH3-40.2
unnamed: C-IGYSH3-13.1, D-IGYSH3-1.2 (K), R-IGYSH3-41.2
unnamed: C-IGYSH3-13.2, R-IGYSH3-22.2, R-IGYSH3-23.1
unnamed: C-IGYSH3-14.1, D-IGYSH3-2.2 (K), R-IGYSH3-42.2, R-IGYSH3-43.2
unnamed: C-IGYSH3-14.2, R-IGYSH3-36.2, R-IGYSH3-37.1
unnamed: C-IGYSH3-15.1, R-IGYSH3-42.1, SW-IGYSH3-1.1 (A)
unnamed: C-IGYSH3-16.1, J-IGYSH3-7.1, RV-IGYSH3-3.2
unnamed: C-IGYSH3-17.1, R-IGYSH3-41.1, R-IGYSH3-43.1, R-IGYSH3-44.1, R-IGYSH3-46.2
unnamed: D-IGYSH3-1.4 (A), D-IGYSH3-2.4 (A), R-IGYSH3-47.2
unnamed: D-IGYSH3-5.4 (A), RV-IGYSH3-1.2
unnamed: D-IGYSH3-9.4 (A), R-IGYSH3-4.1
unnamed: D-IGYSH3-10.4 (A), R-IGYSH3-7.1
unnamed: J-IGYSH3-4.1, R-IGYSH3-6.1, V-IGYSH3-5.6 (K)
unnamed: J-IGYSH3-5.1, R-IGYSH3-12.1, V-IGYSH3-7.6 (K)
unnamed: J-IGYSH3-6.1, R-IGYSH3-33.2, V-IGYSH3-8.6 (K)
unnamed: J-IGYSH3-8.1, R-IGYSH3-48.2, V-IGYSH3-6.6 (K)
unnamed: R-IGYSH3-2.2, V-IGYSH3-1.7 (G1)
unnamed: R-IGYSH3-7.2, V-IGYSH3-5.7 (G1)
unnamed: R-IGYSH3-8.1, V-IGYSH3-1.4 (G3)
unnamed: R-IGYSH3-11.2, V-IGYSH3-7.7 (G1)
unnamed: R-IGYSH3-13.1, V-IGYSH3-2.4 (G3)
unnamed: R-IGYSH3-16.2, V-IGYSH3-2.2 (G2)
unnamed: R-IGYSH3-17.2, V-IGYSH3-2.7 (G1)
unnamed: R-IGYSH3-20.2, V-IGYSH3-3.7 (G1)
unnamed: R-IGYSH3-21.1, RV-IGYSH3-1.3
unnamed: R-IGYSH3-26.1, V-IGYSH3-3.4 (G3)
unnamed: R-IGYSH3-30.1, RV-IGYSH3-2.2
unnamed: R-IGYSH3-31.2, V-IGYSH3-8.7 (G1)
unnamed: R-IGYSH3-34.1, V-IGYSH3-4.4 (G3)
unnamed: R-IGYSH3-38.2, V-IGYSH3-4.2 (G2)
unnamed: R-IGYSH3-39.2, V-IGYSH3-4.7 (G1)
unnamed: R-IGYSH3-45.2, SW-IGYSH3-1.2 (B)
unnamed: R-IGYSH3-47.1, V-IGYSH3-6.7 (G1)

Notes on the sheet:
Auto/Man.Cmn2
Auto/Man.Nc2
Y2 Shift
+10V/-60V
(No longer used.)
Y1 Amp

Schematic: KEYSW1.sch, Key Switches 1 Position 4.6

Parts:
Fn-KEYSW1-1, Fn-KEYSW1-2, Fn-KEYSW1-3: SW_SPDT; A101SYCQ04
J-KEYSW1-1: SUP.ACT.LN; 242431
J-KEYSW1-2: Hs; 242431
J-KEYSW1-3: CL.4; 242431
J-KEYSW1-4: CL.3; 242431
J-KEYSW1-5: CL.2; 242431
J-KEYSW1-6: CL.1; 242431
J-KEYSW1-7: CL.0; 242431
J-KEYSW1-8: CL.15; 242431
J-KEYSW1-9: CL.14; 242431
J-KEYSW1-10: CL.13; 242431
L-KEYSW1-1, L-KEYSW1-2, L-KEYSW1-3, L-KEYSW1-4, L-KEYSW1-5: SW_SPDT; A101SYCQ04
SW-KEYSW1-1: SW_Push; SW_PUSH-12mm
SW-KEYSW1-2: SW_DPDT_x2; 7205SYCQE

Connections:
unnamed: Fn-KEYSW1-1.2 (B), J-KEYSW1-8.1
unnamed: Fn-KEYSW1-1.3 (C), Fn-KEYSW1-2.3 (C), Fn-KEYSW1-3.3 (C), L-KEYSW1-1.3 (C), L-KEYSW1-2.3 (C), L-KEYSW1-3.3 (C), L-KEYSW1-4.3 (C), L-KEYSW1-5.3 (C), SW-KEYSW1-2.2 (B)
unnamed: Fn-KEYSW1-2.2 (B), J-KEYSW1-9.1
unnamed: Fn-KEYSW1-3.2 (B), J-KEYSW1-10.1
unnamed: J-KEYSW1-1.1, SW-KEYSW1-1.1
unnamed: J-KEYSW1-2.1, SW-KEYSW1-1.2
unnamed: J-KEYSW1-3.1, L-KEYSW1-1.2 (B)
unnamed: J-KEYSW1-4.1, L-KEYSW1-2.2 (B)
unnamed: J-KEYSW1-5.1, L-KEYSW1-3.2 (B)
unnamed: J-KEYSW1-6.1, L-KEYSW1-4.2 (B)
unnamed: J-KEYSW1-7.1, L-KEYSW1-5.2 (B)

Notes on the sheet:
Suppress Action Line Switch

Schematic: KEYSW2.sch, Key Switches 2 Position 4.7

Parts:
J-KEYSW2-1: KM.cmn; 242431
J-KEYSW2-2: B; 242431
J-KEYSW2-3: M; 242431
J-KEYSW2-4: MON.S; 242431
J-KEYSW2-5: MON.A; 242431
J-KEYSW2-6: MON.C; 242431
L-KEYSW2-6, L-KEYSW2-7: SW_SPDT; A101SYCQ04
R-KEYSW2-1: 47K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-KEYSW2-2: 100K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
SW6, SW7, SW8, SW9, SW10: SW_Push; PinHeader_1x02_P2.54mm_Vertical
SW-KEYSW2-1, SW-KEYSW2-2: SW_QPDT; PinHeader_1x12_P2.54mm_Vertical
SW-KEYSW2-3: 7205SYCQE; Manufacturer_Part_Number 7205SYCQE; Mouser Part Number 611-7205SYCQE
SW-KEYSW2-4, SW-KEYSW2-5: SW_Push_DPDT; PinHeader_1x06_P2.54mm_Vertical
SW-KEYSW2-16: SW_Double_Acting_Push; PinHeader_1x04_P2.54mm_Vertical

Connections:
/KEYSW2/-65v: L-KEYSW2-6.3 (C), L-KEYSW2-7.3 (C), R-KEYSW2-2.1, SW-KEYSW2-1.6 (C), SW-KEYSW2-2.6 (C)
/KEYSW2/AC.ERASE: L-KEYSW2-6.1 (A), L-KEYSW2-7.1 (A)
/KEYSW2/C.ERASE: L-KEYSW2-6.2 (B), R-KEYSW2-2.2
/KEYSW2/PC.Read: R-KEYSW2-1.1, SW-KEYSW2-1.3 (C)
/KEYSW2/S.ERASE: SW-KEYSW2-2.4 (A), SW-KEYSW2-16.2
unnamed: J-KEYSW2-1.1, SW6.2, SW7.2, SW8.2, SW9.2, SW10.2
unnamed: J-KEYSW2-2.1, SW6.1
unnamed: J-KEYSW2-3.1, SW7.1
unnamed: J-KEYSW2-4.1, SW8.1
unnamed: J-KEYSW2-5.1, SW9.1
unnamed: J-KEYSW2-6.1, SW10.1
unnamed: R-KEYSW2-1.2, SW-KEYSW2-1.5 (B)
unnamed: SW-KEYSW2-3.4 (A), SW-KEYSW2-16.1

Notes on the sheet:
Monitor Switches
To Monitor Chassis
From Stop Chassis
To C.S. Chassis
RUN
STOP
Completion Signal Chassis
Write/ Erase
KMC
To PC Interface
Write
Erase
To Control Store Gate
To Acc Store Gate
KCC
KAC
To PC Interface
KSC
To Write/Erase Chassis
To Inward Transfer Gate

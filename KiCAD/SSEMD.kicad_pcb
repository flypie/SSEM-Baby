# Repository flypie/SSEM-Baby (continued)

## KiCad design KiCAD/SSEMD.kicad_pcb (continued)

Schematic: PSEPCTL.sch, Pulse Separator Control Position 5.3

Parts:
C-PSEPCTL-1, C-PSEPCTL-4: 0.01uf; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-PSEPCTL-2, C-PSEPCTL-9: 0.1uf; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-PSEPCTL-3, C-PSEPCTL-5, C-PSEPCTL-6: 0.5; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-PSEPCTL-7, C-PSEPCTL-8: 0.25uf; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-PSEPCTL--A-1: 0.5; C_Disc_D7.5mm_W5.0mm_P5.00mm
D-PSEPCTL-1, D-PSEPCTL-2, D-PSEPCTL-3: EA50; Valve_B3G
J-PSEPCTL-1: DASH; 242431
J-PSEPCTL-2: HIGH Voltage.; TE_MATE-N-LOK_1-770970-x_2x04_P4.14mm_Horizontal
J-PSEPCTL-3: POS.DASH; 242431
J-PSEPCTL-4: P0; 242431
J-PSEPCTL-5: P1; 242431
J-PSEPCTL-6: P0.CF; 242431
J-PSEPCTL-7: P1.CF; 242431
J-PSEPCTL-8: +20V; 242431
R-PSEPCTL-1: 6K8; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-PSEPCTL-2, R-PSEPCTL-4: 3K3; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-PSEPCTL-3, R-PSEPCTL-9: 1M; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-PSEPCTL-5, R-PSEPCTL-6: 47K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-PSEPCTL-7: 4K7 6w; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-PSEPCTL-8, R-PSEPCTL-10: 100k; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-PSEPCTL-11, R-PSEPCTL-12, R-PSEPCTL-20, R-PSEPCTL-21, R-PSEPCTL-22: 47; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-PSEPCTL-13, R-PSEPCTL-14: 10; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-PSEPCTL-15, R-PSEPCTL-16: 100; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-PSEPCTL-17, R-PSEPCTL-18: 2K2; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-PSEPCTL-19, R-PSEPCTL-23, R-PSEPCTL-24, R-PSEPCTL-25: 10k 6W; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
RV-PSEPCTL-1: 50K; PinHeader_1x03_P2.54mm_Vertical
V-PSEPCTL-1: VR91; Valve_9Loctal
V-PSEPCTL-2, V-PSEPCTL-3: 807; USM5+1
V-PSEPCTL-5, V-PSEPCTL-6, V-PSEPCTL-7: CV173; Valve_9Loctal

Connections:
/PSEPCTL/+50V: C-PSEPCTL-6.1, J-PSEPCTL-2.6
/PSEPCTL/+200V: C-PSEPCTL-3.1, J-PSEPCTL-2.3, R-PSEPCTL-10.1, R-PSEPCTL-19.1, V-PSEPCTL-5.2 (G2), V-PSEPCTL-5.3 (A), V-PSEPCTL-5.4 (G3), V-PSEPCTL-6.2 (G2), V-PSEPCTL-6.3 (A), V-PSEPCTL-6.4 (G3), V-PSEPCTL-7.2 (G2), V-PSEPCTL-7.3 (A), V-PSEPCTL-7.4 (G3)
/PSEPCTL/+300V: C-PSEPCTL--A-1.1, J-PSEPCTL-2.4, R-PSEPCTL-7.1, R-PSEPCTL-9.1, R-PSEPCTL-13.1, R-PSEPCTL-14.1, R-PSEPCTL-15.1, R-PSEPCTL-16.1, V-PSEPCTL-1.2 (G2)
/PSEPCTL/-150V: C-PSEPCTL-5.2, J-PSEPCTL-2.5, R-PSEPCTL-6.1, R-PSEPCTL-17.1, R-PSEPCTL-18.1, R-PSEPCTL-23.2, R-PSEPCTL-24.2, R-PSEPCTL-25.2
/PSEPCTL/GND: C-PSEPCTL-2.2, C-PSEPCTL-3.2, C-PSEPCTL-5.1, C-PSEPCTL-6.2, C-PSEPCTL-9.2, C-PSEPCTL--A-1.2, D-PSEPCTL-3.2 (K), J-PSEPCTL-2.8, R-PSEPCTL-4.1, R-PSEPCTL-8.1, RV-PSEPCTL-1.3, V-PSEPCTL-1.4 (G3), V-PSEPCTL-1.6 (K)
/PSEPCTL/Heater-6.3V: D-PSEPCTL-1.1 (H), D-PSEPCTL-2.1 (H), D-PSEPCTL-3.1 (H), J-PSEPCTL-2.2, V-PSEPCTL-1.9 (H), V-PSEPCTL-2.5 (F1), V-PSEPCTL-3.5 (F1), V-PSEPCTL-5.9 (H), V-PSEPCTL-6.9 (H), V-PSEPCTL-7.9 (H)
/PSEPCTL/Heater-GND: D-PSEPCTL-1.3 (H), D-PSEPCTL-2.3 (H), D-PSEPCTL-3.3 (H), J-PSEPCTL-2.1, V-PSEPCTL-1.1 (H), V-PSEPCTL-2.1 (F1), V-PSEPCTL-3.1 (F1), V-PSEPCTL-5.1 (H), V-PSEPCTL-6.1 (H), V-PSEPCTL-7.1 (H)
unnamed: C-PSEPCTL-1.1, R-PSEPCTL-1.2, R-PSEPCTL-2.2
unnamed: C-PSEPCTL-1.2, J-PSEPCTL-1.1
unnamed: C-PSEPCTL-2.1, D-PSEPCTL-1.4 (A), R-PSEPCTL-3.1, R-PSEPCTL-4.2, R-PSEPCTL-6.2
unnamed: C-PSEPCTL-4.1, D-PSEPCTL-2.2 (K), R-PSEPCTL-9.2, R-PSEPCTL-11.2, R-PSEPCTL-12.2
unnamed: C-PSEPCTL-4.2, R-PSEPCTL-7.2, V-PSEPCTL-1.3 (A)
unnamed: C-PSEPCTL-7.1, C-PSEPCTL-8.1, D-PSEPCTL-3.4 (A), J-PSEPCTL-3.1
unnamed: C-PSEPCTL-7.2, R-PSEPCTL-17.2, V-PSEPCTL-2.2 (K,G3)
unnamed: C-PSEPCTL-8.2, R-PSEPCTL-18.2, V-PSEPCTL-3.2 (K,G3)
unnamed: C-PSEPCTL-9.1, R-PSEPCTL-22.2, RV-PSEPCTL-1.2
unnamed: D-PSEPCTL-1.2 (K), R-PSEPCTL-1.1
unnamed: D-PSEPCTL-2.4 (A), R-PSEPCTL-8.2, R-PSEPCTL-10.2
unnamed: J-PSEPCTL-4.1, R-PSEPCTL-20.2
unnamed: J-PSEPCTL-5.1, R-PSEPCTL-21.2
unnamed: J-PSEPCTL-6.1, R-PSEPCTL-23.1, V-PSEPCTL-5.6 (K)
unnamed: J-PSEPCTL-7.1, R-PSEPCTL-24.1, V-PSEPCTL-6.6 (K)
unnamed: J-PSEPCTL-8.1, R-PSEPCTL-25.1, V-PSEPCTL-7.6 (K)
unnamed: R-PSEPCTL-2.1, R-PSEPCTL-3.2, R-PSEPCTL-5.2
unnamed: R-PSEPCTL-5.1, V-PSEPCTL-1.7 (G1)
unnamed: R-PSEPCTL-11.1, V-PSEPCTL-2.3 (G1)
unnamed: R-PSEPCTL-12.1, V-PSEPCTL-3.3 (G1)
unnamed: R-PSEPCTL-13.2, V-PSEPCTL-2.4 (G2)
unnamed: R-PSEPCTL-14.2, V-PSEPCTL-3.4 (G2)
unnamed: R-PSEPCTL-15.2, V-PSEPCTL-2.6 (A)
unnamed: R-PSEPCTL-16.2, V-PSEPCTL-3.6 (A)
unnamed: R-PSEPCTL-19.2, RV-PSEPCTL-1.1
unnamed: R-PSEPCTL-20.1, V-PSEPCTL-5.7 (G1)
unnamed: R-PSEPCTL-21.1, V-PSEPCTL-6.7 (G1)
unnamed: R-PSEPCTL-22.1, V-PSEPCTL-7.7 (G1)

Notes on the sheet:
(For all 32 Pulse) (Separator Ccts)
May be adjusted to give the widest margins

Schematic: RMONDRS.sch, REMOTE MONITOR DRIVERS Position 2.6

Parts:
C-RMONDRS-1, C-RMONDRS-2, C-RMONDRS-4, C-RMONDRS-8, C-RMONDRS-10: 0.1uf; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-RMONDRS-3, C-RMONDRS-5, C-RMONDRS-6: 0.5; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-RMONDRS-7, C-RMONDRS-9, C-RMONDRS-11: 0.5uf; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-RMONDRS--A-1: 0.5; C_Disc_D7.5mm_W5.0mm_P5.00mm
D-RMONDRS-1, D-RMONDRS-2, D-RMONDRS-3: D; D_5W_P5.08mm_Vertical_KathodeUp
J-RMONDRS-1: S.Read; 242431
J-RMONDRS-2: HIGH Voltage.; TE_MATE-N-LOK_1-770972-x_2x06_P4.14mm_Horizontal
J-RMONDRS-3: Diff.Dot; 242431
J-RMONDRS-4: Ha; 242431
J-RMONDRS-5: S.GRID; 242431
J-RMONDRS-6: R.X1; 242431
J-RMONDRS-7: R.Grid; 242431
J-RMONDRS-8: M.X1; 242431
J-RMONDRS-9, J-RMONDRS-11, J-RMONDRS-15: Y2; 242431
J-RMONDRS-10: M.X2; 242431
J-RMONDRS-12: Y1; 242431
J-RMONDRS-13: R.X2; 242431
J-RMONDRS-14: Conn_02x06_Odd_Even; PinHeader_2x06_P2.54mm_Vertical
R-RMONDRS-1: 15K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-RMONDRS-2, R-RMONDRS-9: 150K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-RMONDRS-3: 1M; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-RMONDRS-4, R-RMONDRS-5, R-RMONDRS-6, R-RMONDRS-11, R-RMONDRS-15, R-RMONDRS-21: R; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-RMONDRS-7: 33K 50W; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-RMONDRS-8: 22K 50W; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-RMONDRS-10, R-RMONDRS-12: 100K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-RMONDRS-13, R-RMONDRS-16, R-RMONDRS-20, R-RMONDRS-22: 22K 3W; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-RMONDRS-14, R-RMONDRS-19: 39K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-RMONDRS-17: 220K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-RMONDRS-18: 560K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
RV-CRTCCT3-4: 250K; Potentiometer_Bourns_3339P_Vertical_HandSoldering
SW-RMONDRS-1: SW_SPST; PinHeader_1x02_P2.54mm_Vertical
SW-RMONDRS-2: SW_SPDT; PinHeader_1x03_P2.54mm_Vertical
T-RMONDRS-1: Transformer_1P_4S; PinHeader_1x10_P2.54mm_Horizontal
V-RMONDRS-1, V-RMONDRS-3, V-RMONDRS-4, V-RMONDRS-5, V-RMONDRS-6: EF50; Valve_9Loctal
V-RMONDRS-2: EF55; Valve_9Loctal
V-RMONDRS-7, V-RMONDRS-8: CV173; Valve_9Loctal

Connections:
/RMONDRS/+50V: C-RMONDRS-6.1, D-RMONDRS-3.1 (K), J-RMONDRS-2.3
/RMONDRS/+200V: C-RMONDRS-3.1, J-RMONDRS-2.2, V-RMONDRS-2.2 (G2), V-RMONDRS-2.3 (A), V-RMONDRS-2.4 (G3)
/RMONDRS/+300V: C-RMONDRS--A-1.1, J-RMONDRS-2.1, J-RMONDRS-14.8, R-RMONDRS-3.1, R-RMONDRS-7.1, R-RMONDRS-8.1, R-RMONDRS-9.2, R-RMONDRS-17.2, V-RMONDRS-3.2 (G2), V-RMONDRS-3.3 (A), V-RMONDRS-3.4 (G3), V-RMONDRS-4.2 (G2), V-RMONDRS-4.3 (A), V-RMONDRS-4.4 (G3), V-RMONDRS-5.2 (G2), V-RMONDRS-5.3 (A), V-RMONDRS-5.4 (G3), V-RMONDRS-6.2 (G2), V-RMONDRS-6.3 (A), V-RMONDRS-6.4 (G3)
/RMONDRS/-150V: C-RMONDRS-5.2, J-RMONDRS-2.4, R-RMONDRS-2.1, R-RMONDRS-18.2
/RMONDRS/GND: C-RMONDRS-2.2, C-RMONDRS-3.2, C-RMONDRS-4.2, C-RMONDRS-5.1, C-RMONDRS-6.2, C-RMONDRS--A-1.2, J-RMONDRS-2.5, J-RMONDRS-2.6, J-RMONDRS-14.7, R-RMONDRS-1.2, R-RMONDRS-10.2, R-RMONDRS-12.2, R-RMONDRS-13.2, R-RMONDRS-16.2, R-RMONDRS-20.2, R-RMONDRS-22.2, SW-RMONDRS-1.2 (B), V-RMONDRS-1.6 (K), V-RMONDRS-8.6 (K)
/RMONDRS/HTR: J-RMONDRS-14.1, J-RMONDRS-14.2
/RMONDRS/Heater-6.3V: J-RMONDRS-2.10, J-RMONDRS-2.12, V-RMONDRS-1.9 (H), V-RMONDRS-2.9 (F1), V-RMONDRS-3.9 (H), V-RMONDRS-4.9 (H), V-RMONDRS-5.9 (H), V-RMONDRS-6.9 (H), V-RMONDRS-7.9 (F1)
/RMONDRS/Heater-GND: J-RMONDRS-2.9, J-RMONDRS-2.11, V-RMONDRS-1.1 (H), V-RMONDRS-2.1 (F1), V-RMONDRS-3.1 (H), V-RMONDRS-4.1 (H), V-RMONDRS-5.1 (H), V-RMONDRS-6.1 (H), V-RMONDRS-7.1 (F1)
unnamed: C-RMONDRS-1.1, R-RMONDRS-10.1, SW-RMONDRS-2.3 (C)
unnamed: C-RMONDRS-1.2, D-RMONDRS-3.2 (A), R-RMONDRS-7.2, V-RMONDRS-1.3 (A), V-RMONDRS-8.3 (A)
unnamed: C-RMONDRS-2.1, R-RMONDRS-8.2, V-RMONDRS-1.2 (G2)
unnamed: C-RMONDRS-4.1, R-RMONDRS-9.1, V-RMONDRS-8.2 (G2)
unnamed: C-RMONDRS-7.1, J-RMONDRS-7.1
unnamed: C-RMONDRS-7.2, R-RMONDRS-12.1, V-RMONDRS-2.6 (K)
unnamed: C-RMONDRS-8.1, J-RMONDRS-8.1
unnamed: C-RMONDRS-8.2, R-RMONDRS-14.1, V-RMONDRS-5.7 (G1)
unnamed: C-RMONDRS-9.1, J-RMONDRS-11.1
unnamed: C-RMONDRS-9.2, R-RMONDRS-16.1, V-RMONDRS-3.6 (K)
unnamed: C-RMONDRS-10.1, J-RMONDRS-10.1
unnamed: C-RMONDRS-10.2, R-RMONDRS-19.1, V-RMONDRS-6.7 (G1)
unnamed: C-RMONDRS-11.1, J-RMONDRS-15.1
unnamed: C-RMONDRS-11.2, R-RMONDRS-22.1, V-RMONDRS-4.6 (K)
unnamed: D-RMONDRS-1.1 (K), J-RMONDRS-1.1
unnamed: D-RMONDRS-1.2 (A), D-RMONDRS-2.2 (A), R-RMONDRS-3.2, R-RMONDRS-4.2
unnamed: D-RMONDRS-2.1 (K), J-RMONDRS-3.1
unnamed: J-RMONDRS-4.1, R-RMONDRS-5.2
unnamed: J-RMONDRS-5.1, SW-RMONDRS-2.1 (A)
unnamed: J-RMONDRS-6.1, R-RMONDRS-13.1, V-RMONDRS-5.6 (K)
unnamed: J-RMONDRS-9.1, R-RMONDRS-15.2
unnamed: J-RMONDRS-12.1, R-RMONDRS-21.2
unnamed: J-RMONDRS-13.1, R-RMONDRS-20.1, V-RMONDRS-6.6 (K)
unnamed: R-RMONDRS-1.1, R-RMONDRS-2.2, R-RMONDRS-6.2
unnamed: R-RMONDRS-4.1, V-RMONDRS-1.7 (G1)
unnamed: R-RMONDRS-5.1, V-RMONDRS-8.4 (G3)
unnamed: R-RMONDRS-6.1, V-RMONDRS-8.7 (G1)
unnamed: R-RMONDRS-11.1, V-RMONDRS-2.7 (G1)
unnamed: R-RMONDRS-11.2, SW-RMONDRS-2.2 (B)
unnamed: R-RMONDRS-14.2, R-RMONDRS-17.1, RV-CRTCCT3-4.1
unnamed: R-RMONDRS-15.1, V-RMONDRS-3.7 (G1)
unnamed: R-RMONDRS-18.1, R-RMONDRS-19.2, RV-CRTCCT3-4.2
unnamed: R-RMONDRS-21.1, V-RMONDRS-4.7 (G1)

Notes on the sheet:
pin7
pin12
pin11
Jones Plug (Viewed from front)
240v
4v for CRT
6.3v for V1,2,3,4&7
6.3v for V5&6
Aux. Htrs. Supply

Schematic: SCFOLLWS.sch, Instruction Gate & Y Shift Position 4.1

Parts:
C-SCFOLLWS-1, C-SCFOLLWS-2, C-SCFOLLWS-7: 0.1u; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-SCFOLLWS-3, C-SCFOLLWS-5, C-SCFOLLWS-6: 0.5; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-SCFOLLWS--A-1: 0.5; C_Disc_D7.5mm_W5.0mm_P5.00mm
D-SCFOLLWS-1, D-SCFOLLWS-2: EA50; Valve_B3G
J-SCFOLLWS-1: XBO; 242431
J-SCFOLLWS-2: HIGH Voltage.; TE_MATE-N-LOK_1-770972-x_2x06_P4.14mm_Horizontal
J-SCFOLLWS-3: Dot.Buff; 242431
J-SCFOLLWS-4, J-SCFOLLWS-10, J-SCFOLLWS-13: XBO.CF; 242431
J-SCFOLLWS-5: Strobe; 242431
J-SCFOLLWS-6, J-SCFOLLWS-9: Dot; 242431
J-SCFOLLWS-7: Strobe.CF; 242431
J-SCFOLLWS-8: Diff Dot; 242431
J-SCFOLLWS-11: Dot.CF; 242431
J-SCFOLLWS-12: Var.Dash; 242431
J-SCFOLLWS-14: Var.Dash.CF; 242431
R-SCFOLLWS-1, R-SCFOLLWS-7, R-SCFOLLWS-13: 10K 6W; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-SCFOLLWS-2, R-SCFOLLWS-4, R-SCFOLLWS-6, R-SCFOLLWS-9, R-SCFOLLWS-11, R-SCFOLLWS-12, R-SCFOLLWS-16, R-SCFOLLWS-18: 470; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-SCFOLLWS-3, R-SCFOLLWS-17: 9K 6W; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-SCFOLLWS-5, R-SCFOLLWS-14, R-SCFOLLWS-19: 7K5 6W; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-SCFOLLWS-8: 470K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-SCFOLLWS-10: 8K2; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-SCFOLLWS-15: 390K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
V-SCFOLLWS-1, V-SCFOLLWS-2, V-SCFOLLWS-3, V-SCFOLLWS-4, V-SCFOLLWS-5, V-SCFOLLWS-6, V-SCFOLLWS-7, V-SCFOLLWS-8, V-SCFOLLWS-9, V-SCFOLLWS-10: CV173; Valve_9Loctal

Connections:
/SCFOLLWS/+50V: C-SCFOLLWS-6.1, J-SCFOLLWS-2.3
/SCFOLLWS/+200V: C-SCFOLLWS-3.1, J-SCFOLLWS-2.2, R-SCFOLLWS-8.2, R-SCFOLLWS-15.2, V-SCFOLLWS-1.2 (G2), V-SCFOLLWS-1.3 (A), V-SCFOLLWS-1.4 (G3), V-SCFOLLWS-2.2 (G2), V-SCFOLLWS-2.3 (A), V-SCFOLLWS-2.4 (G3), V-SCFOLLWS-3.2 (G2), V-SCFOLLWS-3.3 (A), V-SCFOLLWS-3.4 (G3), V-SCFOLLWS-4.2 (G2), V-SCFOLLWS-4.3 (A), V-SCFOLLWS-4.4 (G3), V-SCFOLLWS-5.2 (G2), V-SCFOLLWS-5.3 (A), V-SCFOLLWS-5.4 (G3), V-SCFOLLWS-6.2 (G2), V-SCFOLLWS-6.3 (A), V-SCFOLLWS-6.4 (G3), V-SCFOLLWS-7.2 (G2), V-SCFOLLWS-7.3 (A), V-SCFOLLWS-7.4 (G3), V-SCFOLLWS-8.2 (G2), V-SCFOLLWS-8.3 (A), V-SCFOLLWS-8.4 (G3)
/SCFOLLWS/+300V: C-SCFOLLWS--A-1.1, J-SCFOLLWS-2.1
/SCFOLLWS/-150V: C-SCFOLLWS-5.2, J-SCFOLLWS-2.4, R-SCFOLLWS-1.2, R-SCFOLLWS-3.2, R-SCFOLLWS-5.2, R-SCFOLLWS-7.2, R-SCFOLLWS-13.2, R-SCFOLLWS-14.2, R-SCFOLLWS-17.2, R-SCFOLLWS-19.2
/SCFOLLWS/GND: C-SCFOLLWS-3.2, C-SCFOLLWS-5.1, C-SCFOLLWS-6.2, C-SCFOLLWS--A-1.2, D-SCFOLLWS-1.2 (K), D-SCFOLLWS-2.2 (K), J-SCFOLLWS-2.5, J-SCFOLLWS-2.6, R-SCFOLLWS-10.2
/SCFOLLWS/Heater-6.3V: D-SCFOLLWS-1.1 (H), D-SCFOLLWS-2.1 (H), J-SCFOLLWS-2.10, J-SCFOLLWS-2.12, V-SCFOLLWS-1.9 (F1), V-SCFOLLWS-2.9 (F1), V-SCFOLLWS-3.9 (F1), V-SCFOLLWS-4.9 (F1), V-SCFOLLWS-5.9 (F1), V-SCFOLLWS-6.9 (F1), V-SCFOLLWS-9.9 (H), V-SCFOLLWS-10.9 (H)
/SCFOLLWS/Heater-GND: D-SCFOLLWS-1.3 (H), D-SCFOLLWS-2.3 (H), J-SCFOLLWS-2.9, J-SCFOLLWS-2.11, V-SCFOLLWS-1.1 (F1), V-SCFOLLWS-2.1 (F1), V-SCFOLLWS-3.1 (F1), V-SCFOLLWS-4.1 (F1), V-SCFOLLWS-5.1 (F1), V-SCFOLLWS-6.1 (F1), V-SCFOLLWS-9.1 (H), V-SCFOLLWS-10.1 (H)
unnamed: C-SCFOLLWS-1.1, D-SCFOLLWS-1.4 (A), R-SCFOLLWS-2.1, R-SCFOLLWS-8.1, R-SCFOLLWS-12.1
unnamed: C-SCFOLLWS-1.2, J-SCFOLLWS-9.1
unnamed: C-SCFOLLWS-2.1, D-SCFOLLWS-2.4 (A), R-SCFOLLWS-15.1, R-SCFOLLWS-18.1
unnamed: C-SCFOLLWS-2.2, J-SCFOLLWS-12.1
unnamed: C-SCFOLLWS-7.1, J-SCFOLLWS-6.1
unnamed: C-SCFOLLWS-7.2, R-SCFOLLWS-6.1, R-SCFOLLWS-10.1
unnamed: J-SCFOLLWS-1.1, R-SCFOLLWS-11.1
unnamed: J-SCFOLLWS-3.1, R-SCFOLLWS-3.1, V-SCFOLLWS-5.6 (K)
unnamed: J-SCFOLLWS-4.1, R-SCFOLLWS-1.1, V-SCFOLLWS-1.6 (K)
unnamed: J-SCFOLLWS-5.1, R-SCFOLLWS-4.1
unnamed: J-SCFOLLWS-7.1, R-SCFOLLWS-5.1, V-SCFOLLWS-6.6 (K)
unnamed: J-SCFOLLWS-8.1, R-SCFOLLWS-7.1, V-SCFOLLWS-2.6 (K)
unnamed: J-SCFOLLWS-10.1, R-SCFOLLWS-13.1, V-SCFOLLWS-3.6 (K)
unnamed: J-SCFOLLWS-11.1, R-SCFOLLWS-14.1, V-SCFOLLWS-7.6 (K)
unnamed: J-SCFOLLWS-13.1, R-SCFOLLWS-17.1, V-SCFOLLWS-4.6 (K)
unnamed: J-SCFOLLWS-14.1, R-SCFOLLWS-19.1, V-SCFOLLWS-8.6 (K)
unnamed: R-SCFOLLWS-2.2, V-SCFOLLWS-5.7 (G1)
unnamed: R-SCFOLLWS-4.2, V-SCFOLLWS-6.7 (G1)
unnamed: R-SCFOLLWS-6.2, V-SCFOLLWS-2.7 (G1)
unnamed: R-SCFOLLWS-9.2, V-SCFOLLWS-3.7 (G1)
unnamed: R-SCFOLLWS-11.2, V-SCFOLLWS-1.7 (G1)
unnamed: R-SCFOLLWS-12.2, V-SCFOLLWS-7.7 (G1)
unnamed: R-SCFOLLWS-16.2, V-SCFOLLWS-4.7 (G1)
unnamed: R-SCFOLLWS-18.2, V-SCFOLLWS-8.7 (G1)

Notes on the sheet:
For Remote Monitor
( from V7 )
( Used for ) ( Test Rig )

Schematic: SCLOCK.sch, Clock Position 2.2

Parts:
C-SCLOCK-1, C-SCLOCK-10, C-SCLOCK-25: 470pf; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-SCLOCK-2: 1uF; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-SCLOCK-4, C-SCLOCK-5, C-SCLOCK-7, C-SCLOCK-8, C-SCLOCK-16, C-SCLOCK-18, C-SCLOCK-21: 0.5; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-SCLOCK-11: 50; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-SCLOCK-12: C_Variable; PinHeader_1x02_P2.54mm_Vertical
C-SCLOCK-13: 0.01; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-SCLOCK-14: 27; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-SCLOCK-15, C-SCLOCK-23, C-SCLOCK-24: 100; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-SCLOCK-17: 4uF; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-SCLOCK-19, C-SCLOCK-20, C-SCLOCK-26: 0.1; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-SCLOCK-22: 47; C_Disc_D7.5mm_W5.0mm_P5.00mm
D-SCLOCK-1, D-SCLOCK-2, D-SCLOCK-3, D-SCLOCK-4, D-SCLOCK-5, D-SCLOCK-6, D-SCLOCK-7, D-SCLOCK-8, D-SCLOCK-9: EA50; Valve_B3G
J-SCLOCK-5: HIGH Voltage.; TE_MATE-N-LOK_1-770972-x_2x06_P4.14mm_Horizontal
J-SCLOCK-13: Dash; 242431
J-SCLOCK-14, J-SCLOCK-16: Var.Dash; 242431
J-SCLOCK-15: Div4; 242431
J-SCLOCK-17: P.R.F to Santrig; 242431
L1: L_Coupled; Choke_Schaffner_RN102-04-14.0x14.0mm
R-SCLOCK-1, R-SCLOCK-3, R-SCLOCK-5, R-SCLOCK-24, R-SCLOCK-37, R-SCLOCK-46: 4k7; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-SCLOCK-2: 100k; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-SCLOCK-4: 56K 2W; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-SCLOCK-20: 82K 2W; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-SCLOCK-21, R-SCLOCK-38, R-SCLOCK-41, R-SCLOCK-44: 560; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-SCLOCK-22, R-SCLOCK-43, R-SCLOCK-53: 4K7; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-SCLOCK-23: 3K9; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-SCLOCK-25: 2k7; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-SCLOCK-26, R-SCLOCK-39, R-SCLOCK-48: R; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-SCLOCK-27, R-SCLOCK-47: 390K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-SCLOCK-28: 47K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-SCLOCK-29, R-SCLOCK-45, R-SCLOCK-55: 10K 3W; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-SCLOCK-30, R-SCLOCK-50: 470K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-SCLOCK-31, R-SCLOCK-57: 10K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-SCLOCK-32: 27k; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-SCLOCK-33: 2K2; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-SCLOCK-34: 39K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-SCLOCK-35: 220k; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-SCLOCK-36: 820; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-SCLOCK-40, R-SCLOCK-52: 150K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-SCLOCK-42, R-SCLOCK-58: 15K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-SCLOCK-49: 33K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-SCLOCK-51: 1K5; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-SCLOCK-54: 2K3 6W; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-SCLOCK-56: 100K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
RV-SCLOCK-1, RV-SCLOCK-2: 100K; PinHeader_1x03_P2.54mm_Horizontal
RV-SCLOCK-3: 20K; PinHeader_1x03_P2.54mm_Horizontal
RV-SCLOCK-4: 10K; PinHeader_1x03_P2.54mm_Horizontal
T-SCLOCK-1: Transformer_1P_4S; PinHeader_1x10_P2.54mm_Vertical
V-SCLOCK-1, V-SCLOCK-2: VR91; Valve_9Loctal
V-SCLOCK-3, V-SCLOCK-7, V-SCLOCK-10: CV173; Valve_9Loctal
V-SCLOCK-4, V-SCLOCK-9: 807; USM5+1
V-SCLOCK-5, V-SCLOCK-6, V-SCLOCK-8: VR116; Valve_9Loctal

Connections:
/SCLOCK/200dec: D-SCLOCK-6.2 (K), R-SCLOCK-31.2, RV-SCLOCK-2.3
/SCLOCK/+40V: C-SCLOCK-20.2, R-SCLOCK-23.2, R-SCLOCK-36.2, R-SCLOCK-37.1, R-SCLOCK-44.2
/SCLOCK/+47V: C-SCLOCK-19.2, D-SCLOCK-4.2 (K), D-SCLOCK-7.2 (K), R-SCLOCK-32.2, R-SCLOCK-35.2, R-SCLOCK-36.1, R-SCLOCK-53.1, RV-SCLOCK-2.1
/SCLOCK/+50V: C-SCLOCK-8.1, J-SCLOCK-5.3
/SCLOCK/+200V: C-SCLOCK-5.1, J-SCLOCK-5.2, R-SCLOCK-5.2, R-SCLOCK-30.1, R-SCLOCK-33.1
/SCLOCK/+300V: C-SCLOCK-4.1, J-SCLOCK-5.1, R-SCLOCK-4.1, R-SCLOCK-20.1, R-SCLOCK-28.2, R-SCLOCK-29.2, R-SCLOCK-40.1, R-SCLOCK-42.2, R-SCLOCK-45.2, R-SCLOCK-51.2, R-SCLOCK-52.2, R-SCLOCK-55.2, V-SCLOCK-10.3 (A)
/SCLOCK/-150V: C-SCLOCK-7.2, J-SCLOCK-5.4, R-SCLOCK-50.2, R-SCLOCK-54.2, R-SCLOCK-58.2
/SCLOCK/C: C-SCLOCK-11.1, C-SCLOCK-25.1, R-SCLOCK-51.1, V-SCLOCK-9.6 (A)
/SCLOCK/GND: C-SCLOCK-2.1, C-SCLOCK-4.2, C-SCLOCK-5.2, C-SCLOCK-7.1, C-SCLOCK-8.2, C-SCLOCK-12.2, C-SCLOCK-16.2, C-SCLOCK-17.1, C-SCLOCK-19.1, C-SCLOCK-20.1, C-SCLOCK-21.2, C-SCLOCK-24.2, C-SCLOCK-25.2, C-SCLOCK-26.2, D-SCLOCK-1.4 (A), J-SCLOCK-5.5, J-SCLOCK-5.6, L1.3, R-SCLOCK-2.2, R-SCLOCK-22.2, R-SCLOCK-37.2, R-SCLOCK-43.2, R-SCLOCK-49.1, R-SCLOCK-56.2, RV-SCLOCK-4.1, V-SCLOCK-1.4 (G3), V-SCLOCK-1.6 (K), V-SCLOCK-2.4 (G3), V-SCLOCK-2.6 (K), V-SCLOCK-3.4 (G3), V-SCLOCK-3.6 (K)
/SCLOCK/Heater-6.3V: D-SCLOCK-1.1 (H), D-SCLOCK-2.1 (H), D-SCLOCK-3.1 (H), D-SCLOCK-4.1 (H), D-SCLOCK-5.1 (H), D-SCLOCK-6.1 (H), D-SCLOCK-7.1 (H), D-SCLOCK-8.1 (H), D-SCLOCK-9.1 (H), J-SCLOCK-5.10, J-SCLOCK-5.12, V-SCLOCK-1.9 (H), V-SCLOCK-2.9 (H), V-SCLOCK-3.9 (F1), V-SCLOCK-4.5 (F1), V-SCLOCK-5.8 (F1), V-SCLOCK-6.8 (F1), V-SCLOCK-7.9 (H)
/SCLOCK/Heater-GND: D-SCLOCK-1.3 (H), D-SCLOCK-2.3 (H), D-SCLOCK-3.3 (H), D-SCLOCK-4.3 (H), D-SCLOCK-5.3 (H), D-SCLOCK-6.3 (H), D-SCLOCK-7.3 (H), D-SCLOCK-8.3 (H), D-SCLOCK-9.3 (H), J-SCLOCK-5.9, J-SCLOCK-5.11, V-SCLOCK-1.1 (H), V-SCLOCK-2.1 (H), V-SCLOCK-3.1 (F1), V-SCLOCK-4.1 (F1), V-SCLOCK-5.1 (F1), V-SCLOCK-6.1 (F1), V-SCLOCK-7.1 (H)
unnamed: C-SCLOCK-1.1, D-SCLOCK-2.2 (K), R-SCLOCK-42.1, V-SCLOCK-3.3 (A)
unnamed: C-SCLOCK-1.2, R-SCLOCK-48.2
unnamed: C-SCLOCK-2.2, L1.1, R-SCLOCK-4.2, V-SCLOCK-1.2 (G2)
unnamed: C-SCLOCK-10.1, L1.4
unnamed: C-SCLOCK-10.2, R-SCLOCK-2.1, R-SCLOCK-3.2
unnamed: C-SCLOCK-11.2, D-SCLOCK-5.4 (A), D-SCLOCK-8.4 (A), R-SCLOCK-1.1
unnamed: C-SCLOCK-12.1, C-SCLOCK-13.1, L1.2, V-SCLOCK-1.3 (A)
unnamed: C-SCLOCK-13.2, RV-SCLOCK-1.2
unnamed: C-SCLOCK-14.1, R-SCLOCK-21.1, V-SCLOCK-8.6 (A)
unnamed: C-SCLOCK-14.2, D-SCLOCK-4.4 (A), R-SCLOCK-24.1, R-SCLOCK-27.1
unnamed: C-SCLOCK-15.1, D-SCLOCK-6.4 (A), D-SCLOCK-9.4 (A), R-SCLOCK-31.1
unnamed: C-SCLOCK-15.2, R-SCLOCK-22.1, V-SCLOCK-8.7 (K)
unnamed: C-SCLOCK-16.1, R-SCLOCK-29.1, V-SCLOCK-2.2 (G2)
unnamed: C-SCLOCK-17.2, R-SCLOCK-30.2, R-SCLOCK-32.1, R-SCLOCK-35.1
unnamed: C-SCLOCK-18.1, R-SCLOCK-28.1, R-SCLOCK-34.2, V-SCLOCK-2.3 (A)
unnamed: C-SCLOCK-18.2, R-SCLOCK-34.1, R-SCLOCK-39.2
unnamed: C-SCLOCK-21.1, R-SCLOCK-45.1, V-SCLOCK-3.2 (G2)
unnamed: C-SCLOCK-22.1, R-SCLOCK-41.1, V-SCLOCK-5.6 (A)
unnamed: C-SCLOCK-22.2, D-SCLOCK-7.4 (A), R-SCLOCK-46.1, R-SCLOCK-47.1
unnamed: C-SCLOCK-23.1, R-SCLOCK-56.1, R-SCLOCK-57.2
unnamed: C-SCLOCK-23.2, R-SCLOCK-43.1, V-SCLOCK-5.7 (K)
unnamed: C-SCLOCK-24.1, R-SCLOCK-49.2, R-SCLOCK-50.1
unnamed: C-SCLOCK-26.1, R-SCLOCK-55.1, V-SCLOCK-9.4 (G2)
unnamed: D-SCLOCK-1.2 (K), R-SCLOCK-25.2
unnamed: D-SCLOCK-5.2 (K), J-SCLOCK-14.1, R-SCLOCK-1.2
unnamed: D-SCLOCK-8.2 (K), R-SCLOCK-20.2, R-SCLOCK-21.2
unnamed: D-SCLOCK-9.2 (K), R-SCLOCK-40.2, R-SCLOCK-41.2
unnamed: J-SCLOCK-13.1, R-SCLOCK-54.1, RV-SCLOCK-4.3, V-SCLOCK-9.2 (K,G3)
unnamed: J-SCLOCK-15.1, R-SCLOCK-5.1, V-SCLOCK-8.5 (G2)
unnamed: J-SCLOCK-16.1, RV-SCLOCK-4.2
unnamed: J-SCLOCK-17.1, R-SCLOCK-58.1, V-SCLOCK-10.6 (K)
unnamed: R-SCLOCK-3.1, V-SCLOCK-1.7 (G1)
unnamed: R-SCLOCK-23.1, V-SCLOCK-8.4 (G3)
unnamed: R-SCLOCK-24.2, V-SCLOCK-8.9 (G1)
unnamed: R-SCLOCK-25.1, RV-SCLOCK-1.3
unnamed: R-SCLOCK-26.1, V-SCLOCK-2.7 (G1)
unnamed: R-SCLOCK-26.2, RV-SCLOCK-1.1
unnamed: R-SCLOCK-27.2, RV-SCLOCK-2.2
unnamed: R-SCLOCK-33.2, R-SCLOCK-38.2
unnamed: R-SCLOCK-38.1, V-SCLOCK-5.5 (G2)
unnamed: R-SCLOCK-39.1, V-SCLOCK-3.7 (G1)
unnamed: R-SCLOCK-44.1, V-SCLOCK-5.4 (G3)
unnamed: R-SCLOCK-46.2, V-SCLOCK-5.9 (G1)
unnamed: R-SCLOCK-47.2, RV-SCLOCK-3.2
unnamed: R-SCLOCK-48.1, V-SCLOCK-9.3 (G1)
unnamed: R-SCLOCK-52.1, RV-SCLOCK-3.3
unnamed: R-SCLOCK-53.2, RV-SCLOCK-3.1
unnamed: R-SCLOCK-57.1, V-SCLOCK-10.7 (G1)
unnamed: V-SCLOCK-10.2 (G2), V-SCLOCK-10.4 (G3)

Schematic: SDOT&STB.sch, Clock Position 2.2

Parts:
C-SDOT&STB-3, C-SDOT&STB-27, C-SDOT&STB-31, C-SDOT&STB-32, C-SDOT&STB-33, C-SDOT&STB-38: 47; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-SDOT&STB-4, C-SDOT&STB-5, C-SDOT&STB-7, C-SDOT&STB-8, C-SDOT&STB-28, C-SDOT&STB-29, C-SDOT&STB-36, C-SDOT&STB-41: 0.5; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-SDOT&STB-6: 1000; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-SDOT&STB-9: 200; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-SDOT&STB-30: 50; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-SDOT&STB-34: 0.02; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-SDOT&STB-35, C-SDOT&STB-42: 0.1; C_Disc_D7.5mm_W5.0mm_P5.00mm
C-SDOT&STB-37, C-SDOT&STB-39, C-SDOT&STB-40: 0.01; C_Disc_D7.5mm_W5.0mm_P5.00mm
D-SDOT&STB-1, D-SDOT&STB-2, D-SDOT&STB-3, D-SDOT&STB-4, D-SDOT&STB-5, D-SDOT&STB-6, D-SDOT&STB-7, D-SDOT&STB-8, D-SDOT&STB-9, D-SDOT&STB-10, D-SDOT&STB-11, D-SDOT&STB-12, D-SDOT&STB-13: EA50; Valve_B3G
J-SDOT&STB-1: DASH; 242431
J-SDOT&STB-2: BO.Supp; 242431
J-SDOT&STB-3: STROBE; 242431
J-SDOT&STB-4: DOT; 242431
J-SDOT&STB-5, J-SDOT&STB-7: HIGH Voltage.; TE_MATE-N-LOK_1-770972-x_2x06_P4.14mm_Horizontal
J-SDOT&STB-6: BO; 242431
J-SDOT&STB-8: BO.CF; 242431
J-SDOT&STB-9: XBO; 242431
R-SDOT&STB-6, R-SDOT&STB-7, R-SDOT&STB-8, R-SDOT&STB-9: 4K7; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-SDOT&STB-10: 150K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-SDOT&STB-11: 120K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-SDOT&STB-12, R-SDOT&STB-65, R-SDOT&STB-77, R-SDOT&STB-81, R-SDOT&STB-87, R-SDOT&STB-91: 470; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-SDOT&STB-13, R-SDOT&STB-75, R-SDOT&STB-80, R-SDOT&STB-90: 220K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-SDOT&STB-14, R-SDOT&STB-83: 47K 2W; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-SDOT&STB-15, R-SDOT&STB-84: 3K3; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-SDOT&STB-16: 15K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-SDOT&STB-17: 82K 2W; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-SDOT&STB-18: 5K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-SDOT&STB-19, R-SDOT&STB-76: 470K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-SDOT&STB-59, R-SDOT&STB-63, R-SDOT&STB-68, R-SDOT&STB-70, R-SDOT&STB-78, R-SDOT&STB-79: 100K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-SDOT&STB-60: 22K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-SDOT&STB-61: 3.K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-SDOT&STB-62: 47K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-SDOT&STB-64: 33K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-SDOT&STB-66: 1.8K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-SDOT&STB-67: 8.2K 2W; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-SDOT&STB-69, R-SDOT&STB-82, R-SDOT&STB-85, R-SDOT&STB-92: 15K 2W; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-SDOT&STB-71: 33K 1W; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-SDOT&STB-72, R-SDOT&STB-88: 7.5K 3W; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-SDOT&STB-73, R-SDOT&STB-89: 1M; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-SDOT&STB-74: 5.6M; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-SDOT&STB-86: 560; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R-SDOT&STB-93: 330K; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
RV-SDOT&STB-5, RV-SDOT&STB-6: 10K; PinHeader_1x03_P2.54mm_Horizontal
RV-SDOT&STB-7: 20K; PinHeader_1x03_P2.54mm_Horizontal
V-SDOT&STB-1, V-SDOT&STB-2, V-SDOT&STB-3, V-SDOT&STB-7: VR91; Valve_9Loctal
V-SDOT&STB-4, V-SDOT&STB-5, V-SDOT&STB-6, V-SDOT&STB-8, V-SDOT&STB-11, V-SDOT&STB-12, V-SDOT&STB-13: CV173; Valve_9Loctal

Connections:
/SDOT&STB/+50V: C-SDOT&STB-8.1, J-SDOT&STB-5.3, J-SDOT&STB-7.3
/SDOT&STB/+200V: C-SDOT&STB-5.1, J-SDOT&STB-5.2, J-SDOT&STB-7.2, R-SDOT&STB-6.1, R-SDOT&STB-8.1, R-SDOT&STB-17.1, R-SDOT&STB-60.1, R-SDOT&STB-63.1, R-SDOT&STB-80.1
/SDOT&STB/+300V: C-SDOT&STB-4.1, J-SDOT&STB-5.1, J-SDOT&STB-7.1, R-SDOT&STB-14.1, R-SDOT&STB-16.1, R-SDOT&STB-66.1, R-SDOT&STB-69.1, R-SDOT&STB-71.1, R-SDOT&STB-72.1, R-SDOT&STB-83.1, R-SDOT&STB-85.1, V-SDOT&STB-4.2 (G2), V-SDOT&STB-4.3 (A), V-SDOT&STB-4.4 (G3), V-SDOT&STB-7.2 (G2), V-SDOT&STB-7.3 (A), V-SDOT&STB-7.4 (G3), V-SDOT&STB-8.2 (G2), V-SDOT&STB-8.3 (A), V-SDOT&STB-8.4 (G3)
/SDOT&STB/-150: R-SDOT&STB-73.1, R-SDOT&STB-74.1, R-SDOT&STB-82.1, R-SDOT&STB-88.1, R-SDOT&STB-92.1, RV-SDOT&STB-7.1
/SDOT&STB/-150V: C-SDOT&STB-7.2, J-SDOT&STB-5.4, J-SDOT&STB-7.4
/SDOT&STB/GND: C-SDOT&STB-4.2, C-SDOT&STB-5.2, C-SDOT&STB-7.1, C-SDOT&STB-8.2, C-SDOT&STB-28.1, C-SDOT&STB-29.1, C-SDOT&STB-33.2, C-SDOT&STB-34.2, C-SDOT&STB-35.2, C-SDOT&STB-38.2, D-SDOT&STB-4.2 (K), D-SDOT&STB-6.2 (K), D-SDOT&STB-13.2 (K), J-SDOT&STB-5.5, J-SDOT&STB-5.6, J-SDOT&STB-7.5, J-SDOT&STB-7.6, R-SDOT&STB-7.2, R-SDOT&STB-9.2, R-SDOT&STB-13.1, R-SDOT&STB-18.2, R-SDOT&STB-19.1, R-SDOT&STB-62.1, R-SDOT&STB-68.2, R-SDOT&STB-70.1, R-SDOT&STB-75.1, R-SDOT&STB-76.1, R-SDOT&STB-86.1, R-SDOT&STB-89.1, R-SDOT&STB-90.1, R-SDOT&STB-93.1, RV-SDOT&STB-7.3, V-SDOT&STB-1.6 (K), V-SDOT&STB-5.4 (G3), V-SDOT&STB-5.6 (K), V-SDOT&STB-6.4 (G3), V-SDOT&STB-6.6 (K), V-SDOT&STB-11.4 (G3), V-SDOT&STB-11.6 (K), V-SDOT&STB-13.6 (K)
/SDOT&STB/Heater-6.3V: D-SDOT&STB-1.1 (H), D-SDOT&STB-2.1 (H), D-SDOT&STB-4.1 (H), D-SDOT&STB-5.1 (H), D-SDOT&STB-6.1 (H), D-SDOT&STB-7.1 (H), J-SDOT&STB-5.12, V-SDOT&STB-1.9 (H), V-SDOT&STB-2.9 (H), V-SDOT&STB-3.9 (H), V-SDOT&STB-4.9 (F1), V-SDOT&STB-5.9 (F1), V-SDOT&STB-6.9 (F1), V-SDOT&STB-7.9 (H), V-SDOT&STB-12.9 (F1)
/SDOT&STB/Heater-6.3V+Bal: J-SDOT&STB-5.8, J-SDOT&STB-7.8
/SDOT&STB/Heater-6.3V@100: D-SDOT&STB-3.1 (H), D-SDOT&STB-8.1 (H), D-SDOT&STB-9.1 (H), D-SDOT&STB-11.1 (H), J-SDOT&STB-7.12, R-SDOT&STB-64.1
/SDOT&STB/Heater-6.3V@200: J-SDOT&STB-5.10, J-SDOT&STB-7.10
/SDOT&STB/Heater-GND: D-SDOT&STB-1.3 (H), D-SDOT&STB-2.3 (H), D-SDOT&STB-4.3 (H), D-SDOT&STB-5.3 (H), D-SDOT&STB-6.3 (H), D-SDOT&STB-7.3 (H), J-SDOT&STB-5.11, V-SDOT&STB-1.1 (H), V-SDOT&STB-2.1 (H), V-SDOT&STB-3.1 (H), V-SDOT&STB-4.1 (F1), V-SDOT&STB-5.1 (F1), V-SDOT&STB-6.1 (F1), V-SDOT&STB-7.1 (H), V-SDOT&STB-12.1 (F1)
/SDOT&STB/Heater-GND@100: D-SDOT&STB-3.3 (H), D-SDOT&STB-8.3 (H), D-SDOT&STB-9.3 (H), D-SDOT&STB-11.3 (H), J-SDOT&STB-7.11
/SDOT&STB/Heater-GND@200: J-SDOT&STB-5.9, J-SDOT&STB-7.9
/SDOT&STB/Heater-GND_Bal: J-SDOT&STB-5.7, J-SDOT&STB-7.7
unnamed: C-SDOT&STB-3.1, D-SDOT&STB-3.4 (A), R-SDOT&STB-14.2, R-SDOT&STB-15.1
unnamed: C-SDOT&STB-3.2, R-SDOT&STB-10.1, R-SDOT&STB-11.1, R-SDOT&STB-12.2
unnamed: C-SDOT&STB-6.2, D-SDOT&STB-6.4 (A), D-SDOT&STB-7.2 (K), R-SDOT&STB-13.2
unnamed: C-SDOT&STB-9.1, J-SDOT&STB-1.1
unnamed: C-SDOT&STB-9.2, D-SDOT&STB-1.2 (K), R-SDOT&STB-17.2, R-SDOT&STB-18.1
unnamed: C-SDOT&STB-6.1, C-SDOT&STB-27.1, R-SDOT&STB-15.2, V-SDOT&STB-1.3 (A)
unnamed: C-SDOT&STB-27.2, D-SDOT&STB-1.4 (A), D-SDOT&STB-2.4 (A), R-SDOT&STB-63.2, V-SDOT&STB-11.7 (G1)
unnamed: C-SDOT&STB-28.2, D-SDOT&STB-11.2 (K), R-SDOT&STB-60.2, R-SDOT&STB-61.1, R-SDOT&STB-64.2
unnamed: C-SDOT&STB-29.2, D-SDOT&STB-12.2 (K), R-SDOT&STB-61.2, R-SDOT&STB-62.2
unnamed: C-SDOT&STB-30.1, D-SDOT&STB-7.4 (A), R-SDOT&STB-59.2
unnamed: C-SDOT&STB-30.2, R-SDOT&STB-65.2
unnamed: C-SDOT&STB-31.1, D-SDOT&STB-4.4 (A), R-SDOT&STB-19.2, V-SDOT&STB-1.4 (G3)
unnamed: C-SDOT&STB-31.2, R-SDOT&STB-67.2, V-SDOT&STB-11.3 (A)
unnamed: C-SDOT&STB-32.1, R-SDOT&STB-66.2, R-SDOT&STB-67.1
unnamed: C-SDOT&STB-32.2, R-SDOT&STB-74.2, R-SDOT&STB-76.2, R-SDOT&STB-79.2
unnamed: C-SDOT&STB-33.1, R-SDOT&STB-69.2, V-SDOT&STB-11.2 (G2)
unnamed: C-SDOT&STB-34.1, R-SDOT&STB-72.2, V-SDOT&STB-5.2 (G2), V-SDOT&STB-6.2 (G2)
unnamed: C-SDOT&STB-35.1, D-SDOT&STB-2.2 (K), R-SDOT&STB-68.1, R-SDOT&STB-70.2
unnamed: C-SDOT&STB-36.1, D-SDOT&STB-11.4 (A), D-SDOT&STB-12.4 (A), R-SDOT&STB-71.2, V-SDOT&STB-5.3 (A), V-SDOT&STB-6.3 (A)
unnamed: C-SDOT&STB-36.2, R-SDOT&STB-73.2, R-SDOT&STB-75.2, R-SDOT&STB-81.1
unnamed: C-SDOT&STB-37.2, R-SDOT&STB-77.2, R-SDOT&STB-80.2
unnamed: C-SDOT&STB-38.1, R-SDOT&STB-85.2, V-SDOT&STB-13.2 (G2)
unnamed: C-SDOT&STB-39.1, D-SDOT&STB-10.4 (A), R-SDOT&STB-84.2, V-SDOT&STB-13.3 (A)
unnamed: C-SDOT&STB-39.2, D-SDOT&STB-13.4 (A), R-SDOT&STB-86.2, R-SDOT&STB-87.2
unnamed: C-SDOT&STB-40.1, J-SDOT&STB-6.1
unnamed: C-SDOT&STB-40.2, R-SDOT&STB-89.2, R-SDOT&STB-90.2, R-SDOT&STB-91.1
unnamed: C-SDOT&STB-41.1, C-SDOT&STB-42.1, R-SDOT&STB-92.2, V-SDOT&STB-8.6 (K)
unnamed: C-SDOT&STB-41.2, J-SDOT&STB-8.1
unnamed: C-SDOT&STB-42.2, J-SDOT&STB-9.1, R-SDOT&STB-93.2
unnamed: D-SDOT&STB-3.2 (K), RV-SDOT&STB-6.2
unnamed: J-SDOT&STB-2.1, R-SDOT&STB-78.2
unnamed: J-SDOT&STB-3.1, R-SDOT&STB-82.2, V-SDOT&STB-7.6 (K)
unnamed: J-SDOT&STB-4.1, R-SDOT&STB-88.2, V-SDOT&STB-4.6 (K)
unnamed: R-SDOT&STB-6.2, RV-SDOT&STB-5.1
unnamed: R-SDOT&STB-7.1, RV-SDOT&STB-5.3
unnamed: R-SDOT&STB-8.2, RV-SDOT&STB-6.1
unnamed: R-SDOT&STB-9.1, RV-SDOT&STB-6.3
unnamed: R-SDOT&STB-10.2, R-SDOT&STB-11.2, RV-SDOT&STB-5.2
unnamed: R-SDOT&STB-12.1, V-SDOT&STB-1.7 (G1)
unnamed: R-SDOT&STB-16.2, V-SDOT&STB-1.2 (G2)
unnamed: R-SDOT&STB-59.1, RV-SDOT&STB-7.2
unnamed: R-SDOT&STB-65.1, V-SDOT&STB-5.7 (G1)
unnamed: R-SDOT&STB-77.1, V-SDOT&STB-6.7 (G1)
unnamed: R-SDOT&STB-78.1, V-SDOT&STB-13.4 (G3)
unnamed: R-SDOT&STB-79.1, V-SDOT&STB-13.7 (G1)
unnamed: R-SDOT&STB-81.2, V-SDOT&STB-7.7 (G1)
unnamed: R-SDOT&STB-83.2, R-SDOT&STB-84.1
unnamed: R-SDOT&STB-87.1, V-SDOT&STB-4.7 (G1)
unnamed: R-SDOT&STB-91.2, V-SDOT&STB-8.7 (G1)

Notes on the sheet:
DOT WIDTH
"STROBE DELAY"
From X-Timebase
To Clock

Board: 2 copper layers, 1951 parts (0 on the bottom side), 1194 nets, no tracks yet.
